# Allegro board ADC3XRFXXEVM_E.brd (continued)
## Nets (continued)
N20237066: C413.1 R178.1 U30.19(RFOUTBM)
N20239082: R179.2 U30.30(REXT)
N20249678: C391.2 U30.10(VCCIN)
N20251064: C394.2 R174.1
N20251377: C420.1 R182.2 R183.1
N20251505: C421.1 R183.2 U30.35(VTUNE)
N20257347: R184.1 R185.2 U30.20(MUXOUT)
N20258125: D7.1(ANODE) R185.1
N20306930: C429.1 U32.6(RFC)
N20306944: C430.1 U33.6(RFC)
N198851401: C71.2 R54.1
N198852420: C70.2 R47.1

Pads without a net: J10 A22 A23 A26 A27 A30 A31 A34 A35 A38 A39 B1 B4 B5 B8 B9 B20 B21 B24 B25 B28 B29 B32 B33 B36 B37 B40 C2 C3 C10 C11 C14 C15 C19 C22 C23 C30 C31 C34 C35 C37 C39 D1 D8 D9 D11 D12 D14 D15 D17 D18 D20 D21 D23 D24 D26 D27 D29 D30 D31 D32 D33 D34 D35 D36 D38 D40 E2 E3 E6 E7 E9 E10 E12 E13 E15 E16 E18 E19 E21 E22 E24 E25 E27 E28 E30 E31 E33 E34 E36 E37 E39 F1 F4 F5 F7 F8 F10 F11 F13 F14 F16 F17 F19 F20 F22 F23 F25 F26 F28 F29 F31 F32 F34 F35 F37 F38 F40 G2 G3 G15 G16 G18 G19 G21 G22 G24 G25 G27 G28 G30 G31 G33 G34 G36 G37 G39 H1 H4 H5 H7 H8 H10 H11 H13 H14 H16 H17 H19 H20 H22 H23 H25 H26 H28 H29 H31 H32 H34 H35 H37 H38 H40 J2 J3 J6 J7 J9 J10 J12 J13 J15 J16 J18 J19 J21 J22 J24 J25 J27 J28 J30 J31 J33 J34 J36 J37 J39 K1 K4 K5 K7 K8 K10 K11 K13 K14 K16 K17 K19 K20 K22 K23 K25 K26 K28 K29 K31 K32 K34 K35 K37 K38 K40; T1 2; T2 2; T3 2; T4 2; U3 7 8 9 22 23 24 25 27 28 29 30 37 38 49 50 51 52 56 57 60 61; U5 8 12 13 14 19 22 23 24 27 28; U12 2 4 5 6 9 17 18 19; U15 1 3; U16 3 5 11 12 13; U17 2 3 4 13 14 15 17; U29 6 9; U30 5 28 32; U31 2 4 5 6 9 17 18 19

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 2235 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 167 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 508 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 49 vias
v5: diameter 0.762, hole 0.381, TOP to BOTTOM, 8 vias
v6: diameter 0.61, hole 0.33, TOP to BOTTOM, 16 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.4V: length 24.1
  TOP w0.305: U11.4 60.18,5.35 v1(60.55,4.98)
  TOP w0.508: v1(62.03,3.84) 60.95,3.84 v1(60.71,4.07) R154.1 60.71,4.82 v1(60.55,4.98)
  BOTTOM w0.432: TP28.1 66.75,12.37 ; TP28.1 65.84,10.24 ; TP28.1 64.62,11.46 ; TP28.1 64.92,10.54 ; TP28.1 65.84,12.68 ; TP28.1 64.92,12.37 ; TP28.1 66.75,10.54 ; TP28.1 67.06,11.46
  BOTTOM w0.762: v1(62.03,3.84) 60.95,3.84 v1(60.71,4.07) 60.55,4.23 v1(60.55,4.98) 60.5,4.98 59.49,5.99 59.49,10.57 60.15,11.23 v1(61.7,11.23)
  vias: v1(61.72,14.12) v1(61.7,13.41) v1(61.72,12.74) v1(61.7,11.96) v1(62.61,14.12) v1(62.59,13.41) v1(62.61,12.74) v1(62.59,11.96) v1(62.59,11.23) v1(63.63,14.12) v1(63.6,13.41) v1(63.63,12.74) v1(63.6,11.96) v1(63.6,11.23) v1(69.6,15.67)
3.3VUSB: length 18.1
  BOTTOM w0.305: U5.4 33.11,20.77 33.55,21.21 33.55,23.83 34.72,24.99 36.08,24.99 U29.14
  BOTTOM w0.381: U5.4 30.4,20.77 30.02,20.39 30.02,19.33 26.11,15.42 v1(25.83,15.42) 25.68,15.57 U5.17
  vias: v1(36.11,24.96)
5.0V_IN: length 159.1
  TOP w0.127: v3(33.24,7.68) v3(34.24,7.68) ; v3(33.24,7.68) v3(33.24,8.68) ; v3(33.24,7.68) v3(32.24,7.68) v3(32.24,8.68) ; v3(34.24,7.68) 34.24,8.65 v3(34.23,8.66) ; v3(34.24,7.68) v3(35.24,7.68) ; v3(36.24,8.68) v3(36.24,7.68) v3(35.24,7.68) ; v3(36.24,8.68) v3(35.24,8.68) ; v3(36.24,8.68) v3(36.24,9.68) ; v3(35.24,8.68) v3(35.24,9.68) ; v3(35.24,8.68) v3(35.24,7.68) ; v3(35.24,8.68) 35.22,8.66 v3(34.23,8.66) ; v3(34.23,8.66) 34.23,9.67 v3(34.24,9.68) ; v3(34.23,8.66) 34.21,8.68 v3(33.24,8.68) ; v3(35.24,9.68) v3(34.24,9.68) ; v3(35.24,9.68) v3(36.24,9.68) ; v3(32.24,8.68) v3(33.24,8.68) ; v3(32.24,8.68) v3(32.24,9.68) ; v3(33.24,8.68) v3(33.24,9.68) ; v3(33.24,9.68) v3(34.24,9.68) ; v3(33.24,9.68) v3(32.24,9.68) ; Q1.5 36.14,9.77 v3(36.24,9.68) ; v3(32.24,9.68) 32.33,9.77 Q1.8
  TOP w0.432: J15.1 25.55,10.85 ; J15.1 25.55,7.95 ; J15.1 20.17,9.4 ; J15.1 20.17,10.85 ; J15.1 22.86,7.95 ; J15.1 20.17,7.95 ; J15.1 22.86,10.85 ; J15.1 25.55,9.4 ; 29.44,7.7 TP17.1 ; TP17.1 31.04,9.3 ; TP17.1 29.44,10.9 ; TP17.1 30.62,8.11 ; TP17.1 30.62,10.48 ; TP17.1 27.84,9.3 ; TP17.1 28.26,8.11 ; TP17.1 28.26,10.48
  L4_SIG w0.432: 29.44,7.7 TP17.1 ; TP17.1 29.44,10.9 ; TP17.1 27.84,9.3 ; TP17.1 31.04,9.3 ; TP17.1 30.62,10.48 ; TP17.1 28.26,10.48 ; TP17.1 30.62,8.11 ; TP17.1 28.26,8.11 ; J15.1 25.55,7.95 ; J15.1 22.86,10.85 ; J15.1 20.17,10.85 ; J15.1 20.17,7.95 ; J15.1 25.55,9.4 ; J15.1 25.55,10.85 ; J15.1 22.86,7.95 ; J15.1 20.17,9.4
  L6_PWR w0.432: 28.26,10.48 TP17.1 ; TP17.1 30.62,8.11 ; TP17.1 28.26,8.11 ; TP17.1 27.84,9.3 ; TP17.1 30.62,10.48 ; TP17.1 29.44,10.9 ; TP17.1 29.44,7.7 ; TP17.1 31.04,9.3 ; J15.1 25.55,10.85 ; J15.1 22.86,7.95 ; J15.1 22.86,10.85 ; J15.1 25.55,7.95 ; J15.1 20.17,10.85 ; J15.1 25.55,9.4 ; J15.1 20.17,7.95 ; J15.1 20.17,9.4
  BOTTOM w0.432: 20.17,9.4 J15.1 ; J15.1 20.17,7.95 ; J15.1 25.55,7.95 ; J15.1 25.55,10.85 ; J15.1 20.17,10.85 ; J15.1 25.55,9.4 ; J15.1 22.86,10.85 ; J15.1 22.86,7.95 ; TP17.1 30.62,10.48 ; TP17.1 27.84,9.3 ; TP17.1 28.26,8.11 ; TP17.1 29.44,7.7 ; TP17.1 29.44,10.9 ; TP17.1 28.26,10.48 ; TP17.1 30.62,8.11 ; TP17.1 31.04,9.3
5VIN: length 21.3
  TOP w0.305: U11.1 58.68,6.25 58.83,6.4 U11.7 58.83,9.22 C121.1 ; U14.1 45.01,6.27 U14.7 45.14,6.42 44.45,7.11 ; U18.7 82.73,10.59 C203.1
  L3_PWR w0.432: J38.1 92.43,11.68 ; J38.1 91.26,10.52 ; J38.1 90.09,11.68 ; J38.1 92.14,10.81 ; J38.1 91.26,12.85 ; J38.1 90.38,10.81 ; J38.1 90.38,12.56 ; J38.1 92.14,12.56
  BOTTOM w0.305: 108.61,4.57 108.79,4.75 U12.13 ; U17.10 v1(68.52,14.41)
  vias: v1(20.68,16.31) v1(20.65,15.32) v1(21.51,16.31) v1(21.51,15.32) v1(22.4,16.31) v1(22.38,15.32) v1(43.84,8.77) v1(43.76,7.92) v1(43.76,7.09) v1(43.76,6.3) v1(43.79,5.38) v1(43.76,4.55) v1(44.72,8.77) v1(44.7,7.92) v1(44.7,7.09) v1(44.7,6.3) v1(44.7,5.38) v1(44.68,4.55) v1(57.58,9.6) v1(57.58,8.71) v1(57.58,7.87) v1(57.58,7.09) v1(57.58,6.22) v1(57.56,5.38) v1(58.45,9.58) v1(58.42,8.71) v1(58.42,7.87) v1(58.42,7.09) v1(58.42,6.22) v1(58.39,5.38) v1(66.6,13.74) v1(80.16,5.79) v1(80.8,11) v1(80.8,10.11) v1(80.8,9.22) v1(80.8,8.33) v1(81.51,8.38) v1(81.58,10.98) v1(81.56,10.11) v1(81.56,9.22) v1(82.22,8.38) v1(82.29,10.98) v1(82.32,10.11) v1(82.32,9.22) v1(91.9,7.82) v1(91.9,7.16) v1(91.87,6.48) v1(92.53,6.99) v1(92.53,6.27) v1(92.56,8.33) v1(92.56,7.67) v1(93.24,7.85) v1(93.24,7.19) v1(93.22,6.5) v1(104.55,5.16) v1(104.57,6.5) v1(104.57,5.84) v1(105.23,7.01) v1(105.23,6.35) v1(105.21,5.66) v1(105.21,4.95) v1(105.92,6.53) v1(105.92,5.87) v1(105.89,5.18) v3(32.18,4.29) v3(32.18,3.51) v3(32.31,5.87) v3(32.28,5.11) v3(33.1,5.87) v3(33.1,5.11) v3(33.12,4.29) v3(33.12,3.51) v3(33.91,5.11) v3(33.96,5.87) v3(33.96,4.29) v3(33.96,3.51) v3(34.85,5.08) v3(34.85,4.29) v3(34.85,3.51) v3(34.87,5.89) v3(40.34,8.76) v3(40.31,7.77) v3(41.22,8.76) v3(41.22,7.77) v3(42.11,8.76) v3(42.11,7.77)
+1.9V: length 8.2
  TOP w0.508: SJP5.3 47.57,28.12 48.01,27.69 FB20.3
+2.2V: length 33.9
  TOP w0.305: v1(46.86,4.11) 46.51,4.46 U14.4
  TOP w0.432: TP26.1 51.76,11.74 ; TP26.1 49.94,11.74 ; TP26.1 52.07,12.65 ; TP26.1 49.94,13.56 ; TP26.1 50.85,13.87 ; TP26.1 50.85,11.43 ; TP26.1 51.76,13.56 ; TP26.1 49.63,12.65
  TOP w0.508: v1(46.99,3.28) 47.02,3.3 v1(48.07,3.3) ; v1(46.99,3.28) 46.99,3.99 v1(46.86,4.11) ; v1(46.99,3.28) v1(47.5,3.28)
  BOTTOM w0.432: 49.63,12.65 TP26.1 ; TP26.1 51.76,13.56 ; TP26.1 52.07,12.65 ; TP26.1 50.85,11.43 ; TP26.1 50.85,13.87 ; TP26.1 49.94,11.74 ; TP26.1 51.76,11.74 ; TP26.1 49.94,13.56
  BOTTOM w0.762: v1(48.07,3.3) 47.53,3.3 v1(47.5,3.28) v1(46.99,3.28) 46.99,3.99 v1(46.86,4.11) 46.86,4.83 45.69,5.99 45.69,9.75 46.48,10.54 v1(47.75,10.54) 47.88,10.54
  vias: v1(47.75,13.59) v1(47.75,12.83) v1(47.75,12.06) v1(47.75,11.3) v1(48.51,13.59) v1(48.51,12.83) v1(48.51,12.06) v1(48.51,11.3) v1(48.51,10.54) v1(49.4,13.59) v1(49.4,12.83) v1(49.4,12.06) v1(49.4,11.3) v1(49.4,10.54) v1(50.93,14.53)
+3.3V_LMX: length 26.3
  TOP w0.305: v2(40.03,59.18) 40.04,59.19 v2(40.38,59.19) 40.73,59.19 v2(40.74,59.18) ; v2(40.74,61.7) v2(40.03,61.7) ; v2(45.64,58.06) v2(45.64,58.39) v2(45.64,58.72) ; v2(44.17,64.11) 44.16,64.12 v2(44.16,64.47) 44.15,64.48 v2(44.15,64.85) ; v2(46.79,60.68) v2(46.08,60.68)
  TOP w0.432: 98.25,26.19 TP34.1 ; TP34.1 99.16,26.49 ; TP34.1 99.16,24.05 ; TP34.1 98.25,24.36 ; TP34.1 100.07,26.19 ; TP34.1 100.07,24.36 ; TP34.1 100.38,25.27 ; TP34.1 97.94,25.27
  TOP w0.508: v1(44.02,57.43) 43.56,57.78 43.56,58.6 C398.2
  L3_PWR w0.432: 98.25,26.19 TP34.1 ; TP34.1 100.38,25.27 ; TP34.1 99.16,26.49 ; TP34.1 98.25,24.36 ; TP34.1 97.94,25.27 ; TP34.1 100.07,24.36 ; TP34.1 99.16,24.05 ; TP34.1 100.07,26.19
  BOTTOM w0.305: v1(44.02,57.43) 43.66,57.79 v2(43.66,58.42)
  vias: v1(49.68,63.7) v1(97.66,25.78) v1(97.66,24.89) v1(97.66,24) v1(97.79,26.8) v1(98.68,26.8) v1(100.08,26.67) v1(100.97,26.67) v1(100.97,25.78) v1(100.97,24.89) v1(101.85,26.67) v1(101.85,25.78) v2(40.38,61.69) v2(43.66,58.78) v2(46.43,60.69)
+3.3V_LMXRF: length 1.5
  TOP w0.305: v2(41.43,56.18) 41.48,56.13 C411.1 42.29,56.13 v2(42.34,56.18)
  BOTTOM w0.305: v1(41.88,56.18) v2(42.34,56.18) R177.2 ; R178.2 v2(41.43,56.18)
  vias: v1(24,62.13) v1(24,61.37) v1(24.64,62.33) v1(25.27,62.13) v1(25.27,61.37) v1(38.46,59.92) v1(94.49,25.15) v1(94.49,24.26) v1(94.49,23.37) v1(95.38,25.15) v1(95.38,24.26) v1(95.38,23.37) v1(96.27,25.15) v1(96.27,24.26) v1(96.27,23.37) v2(38.46,60.38) v2(38.46,59.46)
+3.3VCLK: length 30.1
  TOP w0.432: 112.88,22.12 TP12.1 ; TP12.1 113.79,19.99 ; TP12.1 112.88,20.3 ; TP12.1 113.79,22.43 ; TP12.1 114.71,20.3 ; TP12.1 112.57,21.21 ; TP12.1 115.01,21.21 ; TP12.1 114.71,22.12
  L6_PWR w0.432: TP12.1 115.01,21.21 ; TP12.1 113.79,19.99 ; TP12.1 112.57,21.21 ; TP12.1 114.71,20.3 ; TP12.1 113.79,22.43 ; TP12.1 114.71,22.12 ; TP12.1 112.88,20.3 ; TP12.1 112.88,22.12
  BOTTOM w0.432: TP12.1 114.71,22.12 ; TP12.1 113.79,22.43 ; TP12.1 112.88,20.3 ; TP12.1 113.79,19.99 ; TP12.1 112.88,22.12 ; TP12.1 112.57,21.21 ; TP12.1 115.01,21.21 ; TP12.1 114.71,20.3
  vias: v1(71.81,54.33) v1(71.78,53.59) v1(72.14,58.67) v1(72.14,58.04) v1(72.14,55.6) v1(72.14,54.99) v1(72.49,54.33) v1(72.47,53.59) v1(72.77,58.67) v1(72.77,58.06) v1(72.77,55.6) v1(72.77,54.99) v1(76.53,65.46) v1(76.5,64.77) v1(77.14,65.46) v1(77.11,64.74) v1(77.7,65.48) v1(77.67,64.72) v1(85.93,61.19) v1(85.9,60.58) v1(85.88,60.03) v1(85.93,52.37) v1(86.61,61.17) v1(86.61,60.56) v1(86.64,60) v1(87.22,52.98) v1(87.17,51.82) v1(87.81,52.98) v1(87.81,52.37) v1(87.83,51.82) v1(88.94,65.42) v1(88.94,63.17) v1(96.95,65.76) v1(96.95,64.9) v1(97.54,65.33) v1(98.09,65.76) v1(98.09,64.9) v1(103.63,58.7) v1(105.36,63.47) v1(112.01,24.26) v1(112.01,23.62) v1(112.01,22.99) v1(112.65,24.26) v1(112.65,23.62) v1(112.65,22.99) v1(113.28,24.26) v1(113.28,23.62) v1(113.28,22.99) v1(113.92,24.26) v1(113.92,23.62) v1(113.92,22.99)
AVDD1.9V: length 48.3
  TOP w0.254: U1.31 v2(21.62,41) 21.34,41 v1(21.18,40.84) ; U1.10 27.39,48.24 v2(27.61,48.46) ; U1.24 v2(22.28,44.49) 21.28,44.49 v1(21.21,44.55) ; v2(27.39,37.36) U1.45 27.39,37.97 v2(27.36,38) ; U1.39 24.39,37.14 v2(24.23,36.98) v2(23.93,36.68) 23.93,36.32 v1(23.98,36.37) ; v1(24.18,49.07) 24.38,48.87 v2(24.38,48.69) U1.16 ; v2(27.97,36.78) v1(27.97,36.27)
  TOP w0.305: v2(27.61,48.46) v2(27.61,48.82) 27.61,48.92 v1(27.33,49.2) ; v2(27.97,36.78) v2(27.66,37.08) v2(27.39,37.36)
  TOP w0.432: 49.83,23.5 TP20.1 ; TP20.1 52.27,23.5 ; TP20.1 51.97,24.41 ; TP20.1 51.05,22.28 ; TP20.1 51.97,22.58 ; TP20.1 51.05,24.71 ; TP20.1 50.14,22.58 ; TP20.1 50.14,24.41
  L3_PWR w0.432: TP20.1 52.27,23.5 ; TP20.1 50.14,22.58 ; TP20.1 49.83,23.5 ; TP20.1 51.97,24.41 ; TP20.1 51.05,22.28 ; TP20.1 51.97,22.58 ; TP20.1 50.14,24.41 ; TP20.1 51.05,24.71
  BOTTOM w0.305: v1(27.33,49.2) 27.61,48.92 v2(27.61,48.82) v2(27.61,48.46) ; v2(27.36,38) 27.36,37.39 v2(27.39,37.36) v2(27.66,37.08) v2(27.97,36.78) v1(27.97,36.27) ; v1(21.21,44.55) 21.26,44.5 v2(21.74,44.5) 21.76,44.49 v2(22.28,44.49) v2(22.89,44.49) ; v2(24.38,38) v2(24.38,37.49) 24.38,37.13 v2(24.23,36.98) v2(23.93,36.68) 23.93,36.32 v1(23.98,36.37) ; v2(22.89,41) v2(22.48,41) v2(22.02,41) v2(21.62,41) 21.34,41 v1(21.18,40.84) ; v1(24.18,49.07) 24.38,48.87 v2(24.38,48.69) v2(24.38,48.26)
  BOTTOM w0.432: TP20.1 51.97,24.41 ; TP20.1 51.97,22.58 ; TP20.1 51.05,24.71 ; TP20.1 51.05,22.28 ; TP20.1 50.14,22.58 ; TP20.1 50.14,24.41 ; TP20.1 49.83,23.5
  vias: v1(19.3,38.86) v1(19.3,36.63) v1(21.06,35.1) v1(21.06,34.16) v1(47.88,24.38) v1(47.88,23.62) v1(47.88,22.86) v1(47.88,22.1) v1(48.64,24.38) v1(48.64,23.62) v1(48.64,22.86) v1(48.64,22.1) v1(49.4,24.38) v1(49.4,23.62) v1(49.4,22.86) v1(49.4,22.1)
AVDD1.15V: length 49.6
  TOP w0.254: v1(21.18,41.61) 21.31,41.48 v2(21.64,41.48) U1.30 ; v2(28.09,48.41) 28.09,48.36 27.89,48.15 U1.9 ; v2(27.2,36.73) v1(27.2,36.27) ; U1.25 v2(22.28,43.99) 21.4,43.99 v1(21.21,43.79) ; U1.38 v2(23.89,37.56) 23.32,36.98 v2(23.22,36.98) ; U1.46 v2(27.89,38.07) ; v2(28.12,48.79) 28.12,49.17 v1(28.09,49.2) ; v1(23.22,36.37) v2(23.22,36.65) ; U1.44 v2(26.89,37.05)
  TOP w0.305: U1.17 v2(23.89,48.17) v2(23.42,48.64) v1(23.42,49.07) ; v2(23.22,36.65) v2(23.22,36.98) ; v2(28.09,48.41) 28.12,48.44 v2(28.12,48.79) ; v2(26.89,37.05) v2(27.2,36.73)
  L6_PWR w0.152: v2(27.89,38.07) 27.89,38.18 28.19,38.48 28.19,39.37
  L6_PWR w0.305: v2(27.89,38.07) v2(27.89,37.69)
  L6_PWR w0.432: TP22.1 70.74,24.06 ; TP22.1 68.6,23.14 ; TP22.1 71.04,23.14 ; TP22.1 68.91,24.06 ; TP22.1 68.91,22.23 ; TP22.1 69.82,24.36 ; TP22.1 70.74,22.23 ; TP22.1 69.82,21.92
  BOTTOM w0.305: 26.67,37.97 v2(26.87,37.97) v2(26.87,37.49) 26.89,37.48 v2(26.89,37.05) ; 26.67,37.97 26.67,37.34 26.63,37.3 ; 26.67,37.97 26.44,37.97 26.42,38 v2(26.42,37.69) 26.42,37.52 26.63,37.3 ; v1(28.09,49.2) 28.12,49.17 v2(28.12,48.79) 28.09,48.77 v2(28.09,48.41) ; v1(23.22,36.37) v2(23.22,36.65) v2(23.22,36.98) 23.32,36.98 v2(23.6,37.26) 23.89,37.55 v2(23.89,37.56) 23.89,37.96 v2(23.88,37.97) ; v1(27.2,36.27) v2(27.2,36.73) v2(26.89,37.05) ; 24.94,47.47 24.89,47.52 v2(24.89,47.78) v2(26.39,47.78) 26.39,47.45 26.37,47.47 24.94,47.47 ; 24.94,47.47 24.28,47.47 23.89,47.87 v2(23.89,48.17) v2(23.42,48.64) v1(23.42,49.07) ; 26.63,37.3 v2(26.89,37.05) ; v1(21.21,43.79) 21.41,43.99 v2(21.74,43.99) 22.27,43.99 v2(22.28,43.99) v2(22.89,43.99) ; v2(24.92,38.07) 24.87,38.02 v2(24.87,37.67) ; v2(22.89,41.48) v2(22.5,41.48) v2(22.1,41.48) v2(21.64,41.48) 21.31,41.48 v1(21.18,41.61) ; C47.1 27.89,38.05 v2(27.89,37.69)
  BOTTOM w0.432: 68.91,22.23 TP22.1 ; TP22.1 68.6,23.14 ; TP22.1 69.82,24.36 ; TP22.1 68.91,24.06 ; TP22.1 69.82,21.92 ; TP22.1 70.74,24.06 ; TP22.1 71.04,23.14 ; TP22.1 70.74,22.23
  vias: v1(16.87,40.44) v1(68.55,21.49) v1(69.44,21.49) v1(70.33,21.49) v1(71.35,22.38) v1(71.35,21.49) v1(71.37,23.27) v1(72.24,22.38) v1(72.24,21.49) v1(72.26,23.27) v2(24.94,47.42) v2(26.39,47.4) v2(26.39,38.07)
DVDD1.15V: length 82.9
  TOP w0.254: v1(28.73,36.27) v2(28.73,36.7) ; U1.64 v2(32.28,42.98) ; v2(28.39,37.84) 28.39,37.53 v2(28.57,37.34) ; v2(28.78,48.36) 28.39,47.97 U1.8 ; U1.4 30.39,47.91 v2(30.73,48.26) ; v2(28.8,48.77) 28.8,49.15 v1(28.85,49.2)
  TOP w0.305: v1(30.84,49.07) 30.77,49.01 30.77,48.73 30.73,48.69 v2(30.73,48.62) v2(30.73,48.26) ; v2(28.8,48.77) 28.8,48.39 v2(28.78,48.36) ; v1(30.61,36.27) 30.58,36.3 v2(30.58,36.78) v2(30.58,37.19) 30.39,37.38 U1.51 ; v1(33.25,45.97) 33.24,45.99 U1.70 v2(32.28,46) ; v2(28.73,36.7) 28.57,36.86 v2(28.57,37.01) v2(28.57,37.34)
  TOP w0.381: v1(33.17,42.98) v2(32.69,42.98) v2(32.28,42.98) ; U1.57 v2(32.35,39.49)
  TOP w0.432: 84.91,20.34 TP30.1 ; TP30.1 83.69,21.56 ; TP30.1 85.83,22.48 ; TP30.1 84.91,22.78 ; TP30.1 86.13,21.56 ; TP30.1 85.83,20.65 ; TP30.1 84,22.48 ; TP30.1 84,20.65
  L6_PWR w0.305: 28.96,38.1 28.69,37.84 v2(28.39,37.84) 28.57,37.65 v2(28.57,37.34)
  L6_PWR w0.432: 84,20.65 TP30.1 ; TP30.1 83.69,21.56 ; TP30.1 86.13,21.56 ; TP30.1 85.83,20.65 ; TP30.1 84.91,22.78 ; TP30.1 85.83,22.48 ; TP30.1 84,22.48 ; TP30.1 84.91,20.34
  L6_PWR w1.016: 87.88,20.07 104.17,20.07 109.75,14.48 JP1.1 114.45,14.25 v1(114.45,7.75)
  BOTTOM w0.305: v2(30.58,37.19) v2(30.58,36.78) 30.58,36.3 v1(30.61,36.27) ; v1(30.84,49.07) 30.73,48.97 v2(30.73,48.62) v2(30.73,48.26) ; v2(28.78,48.36) 28.78,48.74 v2(28.8,48.77) 28.8,49.15 v1(28.85,49.2) ; v2(28.39,37.84) 28.39,37.53 v2(28.57,37.34) v2(28.57,37.01) 28.57,36.86 v2(28.73,36.7) v1(28.73,36.27) ; v2(32.28,42.98) v2(32.69,42.98)
  BOTTOM w0.381: v2(32.69,42.98) v1(33.17,42.98) ; v2(32.35,39.49) 32.68,39.49 v2(32.69,39.5) ; v1(33.25,45.97) v2(32.69,45.97) 32.31,45.97 v2(32.28,46)
  BOTTOM w0.432: 84,22.48 TP30.1 ; TP30.1 84.91,20.34 ; TP30.1 86.13,21.56 ; TP30.1 84,20.65 ; TP30.1 83.69,21.56 ; TP30.1 85.83,22.48 ; TP30.1 84.91,22.78 ; TP30.1 85.83,20.65
  vias: v1(29.75,50.18) v1(29.67,35.13) v1(38.63,27.48) v1(38.63,26.8) v1(39.29,27.48) v1(39.29,26.8) v1(83.82,20.12) v1(83.79,19.3) v1(83.79,18.49) v1(84.63,20.12) v1(84.61,19.3) v1(84.61,18.49) v1(85.45,19.3) v1(85.45,18.49) v1(85.47,20.12)
GND: length 2537
  TOP w0.127: v3(31.58,40.11) v3(30.27,40.11)
  TOP w0.152: 30.89,45.99 v3(31.58,46.68) 31.59,46.68 v1(32.61,47.7) ; v2(18.03,44.53) U32.2 18.03,45.16 17.75,45.44 ; v1(31.6,49.27) 31.6,49.1 31.13,48.63 31.13,48.1 30.89,47.86 U1.3 ; v3(31.58,38.79) 32.47,37.9
  TOP w0.203: v2(18.03,44.53) 18.11,44.53 18.16,44.48 18.59,44.48 18.87,44.75 v2(18.87,45.19) ; 17.83,41.81 v2(17.22,41.81)
  TOP w0.229: v1(29.67,36.14) 29.67,37.08 29.54,37.21 29.54,37.43 v2(29.39,37.58) U1.49 ; v1(32.77,37.74) 32.63,37.74 32.47,37.9
  TOP w0.254: v3(28.95,44.05) 29.39,44.49 U1.67 34.43,44.49 v1(34.44,44.5) ; v1(32.77,37.74) 32.87,37.64 33.32,37.64 34.42,36.55 ; v3(23.69,46.68) 23.39,46.99 U1.18 ; v1(20.47,40.84) 20.47,40.67 20.78,40.36 21.46,40.36 21.59,40.49 U1.32 25.39,40.49 ; v3(23.69,38.79) 23.39,38.49 U1.37 ; v1(34.37,46.76) 34.21,46.76 ; 26.89,43.49 U1.26 21.63,43.49 21.46,43.31 20.96,43.31 20.5,43.77 v1(20.5,43.79) ; v1(20.47,41.61) 20.47,41.62 20.94,42.09 21.43,42.09 21.53,41.99 U1.29 26.89,41.99 ; 31.29,36.68 31.04,36.93 31.04,37.36 30.89,37.52 U1.52 30.89,39.49 v3(30.27,40.11) 29.39,40.99 U1.60 v1(33.24,40.99) 34.05,40.99 v1(34.34,40.69) ; U1.23 21.46,44.99 21.41,45.03 20.96,45.03 20.5,44.57 v1(20.5,44.55) ; U1.3 30.89,45.99
  TOP w0.305: v1(60.43,6.58) 60.17,6.58 60.03,6.72 U11.5 ; U18.5 83.93,8.12 84.1,7.95 v1(84.35,7.95) ; U18.5 v1(84.43,8.66) ; U18.5 83.93,9.18 84.1,9.35 v1(84.35,9.35) ; v1(46.76,6.53) 46.76,7.04 v1(46.74,7.06) 46.74,7.04 46.46,6.76 46.46,6.32 v1(46.76,6.02) v1(46.76,6.53) ; v1(46.76,6.53) 46.47,6.53 U14.5 ; U11.5 v1(60.49,7.3) ; U11.5 60.03,7.88 60.15,8 v1(60.45,8) ; v1(28.85,49.91) 28.8,49.86 C37.2 27.38,49.86 v1(27.33,49.91) ; v6(44.93,62.97) 44.45,63.45 C401.2 v6(43.92,62.97) ; v3(26.32,41.42) v3(25.01,40.11) v3(23.69,38.79) ; v3(23.69,46.68) v3(25.01,45.37) ; v6(41.88,59.92) 41.35,59.39 C397.2 ; v3(27.64,42.74) v3(26.32,44.05) 25.39,44.99 U1.23 ; v3(27.64,42.74) 26.89,41.99 ; v3(27.64,42.74) v3(28.95,41.42) ; C94.1 v1(81.31,67.41) ; v6(41.88,61.95) 41.76,61.95 41.5,61.7 C390.1 ; v6(44.93,60.93) 45.19,60.68 C392.2 ; v3(30.27,45.37) 30.89,45.99 ; U1.49 29.39,40.99
  TOP w0.381: v1(28.73,35.56) v1(27.97,35.56) v1(27.2,35.56) ; R89.2 125.37,58.91 v1(125.09,59.18)
  TOP w0.432: 111.34,54.56 J14.2 ; J14.2 111.78,55.79 ; J14.2 113,52.89 ; J14.2 114.23,53.33 ; J14.2 111.78,53.33 ; J14.2 114.67,54.56 ; J14.2 113,56.22 ; J14.2 114.23,55.79 ; TP19.1 110.01,27.08 ; TP19.1 108.18,27.08 ; TP19.1 109.09,24.94 ; TP19.1 110.01,25.25 ; TP19.1 109.09,27.38 ; TP19.1 108.18,25.25 ; TP19.1 107.87,26.16 ; TP19.1 110.31,26.16 ; 27.82,5.45 TP18.1 ; TP18.1 30.19,5.45 ; TP18.1 29.01,2.67 ; TP18.1 29.01,5.87 ; TP18.1 30.19,3.08 ; TP18.1 27.82,3.08 ; TP18.1 30.61,4.27 ; TP18.1 27.41,4.27 ; J14.3 119.75,54.56 ; J14.3 118.08,52.89 ; J14.3 116.42,54.56 ; J14.3 116.86,55.79 ; J14.3 119.31,53.33 ; J14.3 118.08,56.22 ; J14.3 119.31,55.79 ; J14.3 116.86,53.33 ; 41.38,17.55 TP27.1 ; TP27.1 41.38,15.72 ; TP27.1 42.29,17.86 ; TP27.1 43.2,15.72 ; TP27.1 41.07,16.64 ; TP27.1 43.2,17.55 ; TP27.1 42.29,15.42 ; TP27.1 43.51,16.64 ; 111.34,65.35 J13.2 ; J13.2 114.23,64.13 ; J13.2 111.78,64.13 ; J13.2 113,63.69 ; J13.2 111.78,66.58 ; J13.2 114.23,66.58 ; J13.2 113,67.02 ; J13.2 114.67,65.35 ; JP2.1 34.57,67.39 ; JP2.1 34.57,65.05 ; JP2.1 32.23,67.39 ; JP2.1 34.57,66.22 ; JP2.1 32.23,66.22 ; JP2.1 33.4,67.39 ; JP2.1 33.4,65.05 ; JP2.1 32.23,65.05 ; TP31.1 90.42,23.83 ; TP31.1 91.64,22.61 ; TP31.1 89.51,23.52 ; TP31.1 90.42,21.39 ; TP31.1 91.34,21.69 ; TP31.1 91.34,23.52 ; TP31.1 89.51,21.69 ; TP31.1 89.2,22.61 ; J7.5 54.52,61.81 ; J7.5 52.06,61.81 ; J7.5 51.62,60.58 ; J7.5 54.52,59.35 ; J7.5 54.95,60.58 ; J7.5 53.29,58.91 ; J7.5 52.06,59.35 ; J7.5 53.29,62.24 ; 116.86,64.13 J13.3 ; J13.3 119.31,64.13 ; J13.3 116.42,65.35 ; J13.3 116.86,66.58 ; J13.3 118.08,63.69 ; J13.3 118.08,67.02 ; J13.3 119.31,66.58 ; J13.3 119.75,65.35 ; J14.4 119.31,50.71 ; J14.4 119.75,49.48 ; J14.4 118.08,47.81 ; J14.4 116.86,50.71 ; J14.4 116.86,48.25 ; J14.4 118.08,51.14 ; J14.4 116.42,49.48 ; 73.51,6.5 TP29.1 ; TP29.1 75.64,7.42 ; TP29.1 73.81,5.59 ; TP29.1 74.73,5.28 ; TP29.1 75.64,5.59 ; TP29.1 73.81,7.42 ; TP29.1 75.95,6.5 ; TP29.1 74.73,7.72 ; 113,47.81 J14.5 ; J14.5 114.67,49.48 ; J14.5 114.23,48.25 ; J14.5 113,51.14 ; J14.5 111.78,50.71 ; J14.5 111.34,49.48 ; J14.5 111.78,48.25 ; J14.5 114.23,50.71 ; 15.91,4.01 J15.2 ; J15.2 17.36,8.89 ; J15.2 17.36,4.01 ; J15.2 15.91,8.89 ; J15.2 18.81,6.45 ; J15.2 18.81,8.89 ; J15.2 15.91,6.45 ; J38.2 92.43,14.22 ; J38.2 91.26,13.06 ; J38.2 92.14,15.1 ; J38.2 90.09,14.22 ; J38.2 90.38,15.1 ; J38.2 92.14,13.35 ; J38.2 90.38,13.35 ; J38.2 91.26,15.39 ; 58.12,20.83 TP21.1 ; TP21.1 57.2,22.96 ; TP21.1 56.9,22.05 ; TP21.1 59.33,22.05 ; TP21.1 59.03,21.13 ; TP21.1 58.12,23.27 ; TP21.1 57.2,21.13 ; TP21.1 59.03,22.96 ; J15.3 20.06,6.29 ; J15.3 21.51,1.41 ; J15.3 18.61,1.41 ; J15.3 20.06,1.41 ; J15.3 21.51,6.29 ; J15.3 18.61,3.85 ; J15.3 21.51,3.85 ; 26.63,62.47 JP3.2 ; JP3.2 28.39,64.22 ; JP3.2 26.34,63.35 ; JP3.2 28.39,62.47 ; JP3.2 27.51,62.18 ; JP3.2 28.68,63.35 ; JP3.2 27.51,64.52 ; JP3.2 26.63,64.22 ; 113,58.61 J13.5 ; J13.5 113,61.94 ; J13.5 111.78,59.05 ; J13.5 114.23,61.5 ; J13.5 111.34,60.27 ; J13.5 111.78,61.5 ; J13.5 114.67,60.27 ; J13.5 114.23,59.05 ; J7.3 60.03,65.66 ; J7.3 58.37,63.99 ; J7.3 57.14,66.89 ; J7.3 58.37,67.32 ; J7.3 57.14,64.43 ; J7.3 59.6,64.43 ; J7.3 59.6,66.89 ; J7.3 56.7,65.66 ; 118.59,14.48 JP1.3 ; JP1.3 119.76,15.65 ; JP1.3 118.88,15.36 ; JP1.3 119.76,13.31 ; JP1.3 120.93,14.48 ; JP1.3 120.64,15.36 ; JP1.3 120.64,13.6 ; JP1.3 118.88,13.6 ; 51.62,65.66 J7.2 ; J7.2 52.06,64.43 ; J7.2 53.29,63.99 ; J7.2 52.06,66.89 ; J7.2 53.29,67.32 ; J7.2 54.52,66.89 ; J7.2 54.95,65.66 ; J7.2 54.52,64.43 ; 116.42,60.27 J13.4 ; J13.4 119.31,61.5 ; J13.4 118.08,61.94 ; J13.4 116.86,59.05 ; J13.4 118.08,58.61 ; J13.4 116.86,61.5 ; J13.4 119.31,59.05 ; J13.4 119.75,60.27 ; J7.4 59.6,59.35 ; J7.4 57.14,61.81 ; J7.4 56.7,60.58 ; J7.4 57.14,59.35 ; J7.4 58.37,58.91 ; J7.4 58.37,62.24 ; J7.4 60.03,60.58 ; J7.4 59.6,61.81
  TOP w0.508: v6(42.9,59.92) 43.13,59.69 C398.1 43.69,59.69 v6(43.92,59.92) ; C90.1 76.17,53.85 v1(76.43,54.1) ; v4(82.96,59.39) 83.21,59.13 C98.1 ; v4(78.9,54.31) 78.72,54.13 C97.2 78.06,54.13 v4(77.88,54.31) ; R125.1 110.11,7.01 v3(109.8,7.31) 109.5,7.01 R124.1 109.09,7.01 v3(108.79,7.31) 108.48,7.01 C166.2 108.08,7.01 v3(107.77,7.31) ; v3(97.13,8.51) 97.43,8.2 R172.1 ; v6(43.92,62.97) 43.69,63.2 C402.1 43.13,63.2 v6(42.9,62.97) ; v4(79.91,54.31) 79.63,54.02 C88.1 ; v4(82.96,54.31) 83.34,53.93 C99.1 ; v4(76.86,55.32) 76.59,55.6 C91.1 ; v4(76.86,60.4) 76.48,60.78 C87.1 ; C387.2 95.4,8.2 v3(95.1,8.51) ; v3(109.8,8.33) 109.83,8.36 110.11,8.36 ; v3(97.13,9.53) 97.16,9.55 R171.1 ; R170.1 96.42,8.2 v3(96.11,8.51) ; C89.1 77.8,60.48 v4(77.88,60.4) ; v4(76.86,58.37) 76.56,58.06 C92.1 ; 51.79,16.05 51.57,16.05 v3(51.43,16.2) ; C96.2 77.24,53.93 v4(76.86,54.31)
  L2_GND w0.432: 116.86,59.05 J13.4 ; J13.4 118.08,58.61 ; J13.4 116.86,61.5 ; J13.4 116.42,60.27 ; J13.4 119.31,61.5 ; J13.4 119.75,60.27 ; J13.4 118.08,61.94 ; J13.4 119.31,59.05 ; J13.2 114.23,66.58 ; J13.2 113,63.69 ; J13.2 111.34,65.35 ; J13.2 113,67.02 ; J13.2 114.23,64.13 ; J13.2 114.67,65.35 ; J13.2 111.78,64.13 ; J13.2 111.78,66.58 ; 57.14,64.43 J7.3 ; J7.3 58.37,63.99 ; J7.3 56.7,65.66 ; J7.3 58.37,67.32 ; J7.3 57.14,66.89 ; J7.3 59.6,66.89 ; J7.3 59.6,64.43 ; J7.3 60.03,65.66 ; JP3.2 28.39,64.22 ; JP3.2 26.63,64.22 ; JP3.2 27.51,62.18 ; JP3.2 28.39,62.47 ; JP3.2 26.34,63.35 ; JP3.2 28.68,63.35 ; JP3.2 27.51,64.52 ; JP3.2 26.63,62.47 ; TP31.1 91.64,22.61 ; TP31.1 89.51,21.69 ; TP31.1 91.34,21.69 ; TP31.1 89.51,23.52 ; TP31.1 91.34,23.52 ; TP31.1 90.42,23.83 ; TP31.1 90.42,21.39 ; TP31.1 89.2,22.61 ; 90.38,15.1 J38.2 ; J38.2 90.09,14.22 ; J38.2 92.14,15.1 ; J38.2 92.14,13.35 ; J38.2 91.26,13.06 ; J38.2 90.38,13.35 ; J38.2 92.43,14.22 ; J38.2 91.26,15.39 ; MT2.1 12.7,5.19 ; MT2.1 14.18,4.65 ; MT2.1 12.7,1.16 ; MT2.1 11.22,4.65 ; MT2.1 10.68,3.17 ; MT2.1 14.72,3.17 ; MT2.1 11.22,1.7 ; MT2.1 14.18,1.7 ; J7.5 54.95,60.58 ; J7.5 54.52,59.35 ; J7.5 53.29,58.91 ; J7.5 52.06,59.35 ; J7.5 51.62,60.58 ; J7.5 54.52,61.81 ; J7.5 52.06,61.81 ; J7.5 53.29,62.24 ; J15.2 18.81,6.45 ; J15.2 15.91,6.45 ; J15.2 15.91,4.01 ; J15.2 15.91,8.89 ; J15.2 18.81,8.89 ; J15.2 17.36,8.89 ; J15.2 17.36,4.01 ; J13.5 114.23,59.05 ; J13.5 114.23,61.5 ; J13.5 114.67,60.27 ; J13.5 111.34,60.27 ; J13.5 113,58.61 ; J13.5 113,61.94 ; J13.5 111.78,59.05 ; J13.5 111.78,61.5 ; 58.37,58.91 J7.4 ; J7.4 57.14,61.81 ; J7.4 56.7,60.58 ; J7.4 59.6,61.81 ; J7.4 59.6,59.35 ; J7.4 58.37,62.24 ; J7.4 60.03,60.58 ; J7.4 57.14,59.35 ; J14.2 113,56.22 ; J14.2 111.34,54.56 ; J14.2 113,52.89 ; J14.2 111.78,53.33 ; J14.2 114.67,54.56 ; J14.2 111.78,55.79 ; J14.2 114.23,53.33 ; J14.2 114.23,55.79 ; 42.29,15.42 TP27.1 ; TP27.1 43.2,17.55 ; TP27.1 43.51,16.64 ; TP27.1 42.29,17.86 ; TP27.1 41.07,16.64 ; TP27.1 41.38,15.72 ; TP27.1 43.2,15.72 ; TP27.1 41.38,17.55 ; JP2.1 34.28,65.34 ; JP2.1 32.52,67.1 ; JP2.1 34.57,66.22 ; JP2.1 33.4,67.39 ; JP2.1 32.23,66.22 ; JP2.1 33.4,65.05 ; JP2.1 34.28,67.1 ; JP2.1 32.52,65.34 ; JP1.3 120.64,15.36 ; JP1.3 120.93,14.48 ; JP1.3 118.88,13.6 ; JP1.3 119.76,15.65 ; JP1.3 118.59,14.48 ; JP1.3 120.64,13.6 ; JP1.3 118.88,15.36 ; JP1.3 119.76,13.31 ; J14.5 114.23,48.25 ; J14.5 113,51.14 ; J14.5 111.78,50.71 ; J14.5 114.23,50.71 ; J14.5 114.67,49.48 ; J14.5 111.34,49.48 ; J14.5 111.78,48.25 ; J14.5 113,47.81 ; TP18.1 30.19,3.08 ; TP18.1 27.41,4.27 ; TP18.1 30.19,5.45 ; TP18.1 27.82,3.08 ; TP18.1 30.61,4.27 ; TP18.1 27.82,5.45 ; TP18.1 29.01,5.87 ; TP18.1 29.01,2.67 ; TP19.1 109.09,27.38 ; TP19.1 110.31,26.16 ; TP19.1 109.09,24.94 ; TP19.1 108.18,25.25 ; TP19.1 107.87,26.16 ; TP19.1 108.18,27.08 ; TP19.1 110.01,25.25 ; TP19.1 110.01,27.08 ; J15.3 21.51,1.41 ; J15.3 18.61,3.85 ; J15.3 20.06,1.41 ; J15.3 21.51,3.85 ; J15.3 18.61,1.41 ; J15.3 21.51,6.29 ; J15.3 20.06,6.29 ; 73.81,5.59 TP29.1 ; TP29.1 73.51,6.5 ; TP29.1 75.95,6.5 ; TP29.1 73.81,7.42 ; TP29.1 75.64,5.59 ; TP29.1 74.73,5.28 ; TP29.1 75.64,7.42 ; TP29.1 74.73,7.72 ; 116.86,48.25 J14.4 ; J14.4 118.08,47.81 ; J14.4 119.31,48.25 ; J14.4 118.08,51.14 ; J14.4 119.75,49.48 ; J14.4 116.42,49.48 ; J14.4 116.86,50.71 ; J14.4 119.31,50.71 ; J14.3 118.08,56.22 ; J14.3 119.75,54.56 ; J14.3 118.08,52.89 ; J14.3 119.31,53.33 ; J14.3 119.31,55.79 ; J14.3 116.42,54.56 ; J14.3 116.86,53.33 ; J14.3 116.86,55.79 ; 57.2,22.96 TP21.1 ; TP21.1 58.12,20.83 ; TP21.1 56.9,22.05 ; TP21.1 59.03,22.96 ; TP21.1 59.03,21.13 ; TP21.1 59.33,22.05 ; TP21.1 58.12,23.27 ; TP21.1 57.2,21.13 ; 118.08,63.69 J13.3 ; J13.3 116.86,64.13 ; J13.3 119.31,64.13 ; J13.3 116.42,65.35 ; J13.3 116.86,66.58 ; J13.3 119.31,66.58 ; J13.3 118.08,67.02 ; J13.3 119.75,65.35 ; 21.59,63.39 MT1.1 ; MT1.1 19.57,65.41 ; MT1.1 20.11,63.93 ; MT1.1 23.07,63.93 ; MT1.1 21.59,67.42 ; MT1.1 20.11,66.88 ; MT1.1 23.61,65.41 ; MT1.1 23.07,66.88 ; J7.2 54.52,66.89 ; J7.2 51.62,65.66 ; J7.2 52.06,64.43 ; J7.2 54.95,65.66 ; J7.2 53.29,63.99 ; J7.2 52.06,66.89 ; J7.2 54.52,64.43 ; J7.2 53.29,67.32
  L3_PWR w0.432: 116.86,48.25 J14.4 ; J14.4 118.08,47.81 ; J14.4 119.31,48.25 ; J14.4 116.42,49.48 ; J14.4 116.86,50.71 ; J14.4 118.08,51.14 ; J14.4 119.31,50.71 ; J14.4 119.75,49.48 ; MT1.1 21.59,67.42 ; MT1.1 19.57,65.41 ; MT1.1 20.11,66.88 ; MT1.1 20.11,63.93 ; MT1.1 23.07,66.88 ; MT1.1 21.59,63.39 ; MT1.1 23.07,63.93 ; 56.9,22.05 TP21.1 ; TP21.1 58.12,23.27 ; TP21.1 57.2,21.13 ; TP21.1 58.12,20.83 ; TP21.1 59.03,21.13 ; TP21.1 59.33,22.05 ; TP21.1 57.2,22.96 ; TP21.1 59.03,22.96 ; 118.08,63.69 J13.3 ; J13.3 119.31,64.13 ; J13.3 116.86,66.58 ; J13.3 119.31,66.58 ; J13.3 118.08,67.02 ; J13.3 116.86,64.13 ; J13.3 116.42,65.35 ; J13.3 119.75,65.35 ; J13.2 114.23,66.58 ; J13.2 111.78,64.13 ; J13.2 113,67.02 ; J13.2 114.67,65.35 ; J13.2 113,63.69 ; J13.2 111.34,65.35 ; J13.2 111.78,66.58 ; J13.2 114.23,64.13 ; 109.09,24.94 TP19.1 ; TP19.1 108.18,27.08 ; TP19.1 110.01,25.25 ; TP19.1 110.01,27.08 ; TP19.1 109.09,27.38 ; TP19.1 110.31,26.16 ; TP19.1 107.87,26.16 ; TP19.1 108.18,25.25 ; 32.52,67.1 JP2.1 ; JP2.1 33.4,67.39 ; JP2.1 33.89,67.36 ; JP2.1 34.28,67.1 ; J7.3 58.37,67.32 ; J7.3 57.14,66.89 ; J7.3 60.03,65.66 ; J7.3 59.6,66.89 ; J7.3 57.14,64.43 ; J7.3 56.7,65.66 ; J7.3 59.6,64.43 ; J7.3 58.37,63.99 ; 116.42,54.56 J14.3 ; J14.3 119.31,53.33 ; J14.3 116.86,53.33 ; J14.3 119.75,54.56 ; J14.3 119.31,55.79 ; J14.3 118.08,56.22 ; J14.3 116.86,55.79 ; J14.3 118.08,52.89 ; J13.5 114.23,59.05 ; J13.5 111.78,59.05 ; J13.5 113,58.61 ; J13.5 111.78,61.5 ; J13.5 111.34,60.27 ; J13.5 114.23,61.5 ; J13.5 113,61.94 ; J13.5 114.67,60.27 ; J7.2 54.95,65.66 ; J7.2 53.29,67.32 ; J7.2 52.06,66.89 ; J7.2 54.52,64.43 ; J7.2 54.52,66.89 ; 113,52.89 J14.2 ; J14.2 111.78,55.79 ; J14.2 111.34,54.56 ; J14.2 114.23,53.33 ; J14.2 113,56.22 ; J14.2 111.78,53.33 ; J14.2 114.67,54.56 ; J14.2 114.23,55.79 ; 57.14,61.81 J7.4 ; J7.4 58.37,62.24 ; J7.4 59.6,59.35 ; J7.4 59.6,61.81 ; J7.4 60.03,60.58 ; 20.06,1.41 J15.3 ; J15.3 21.51,3.85 ; J15.3 21.51,1.41 ; J15.3 18.61,3.85 ; J15.3 20.06,6.29 ; J15.3 21.51,6.29 ; J15.3 18.61,1.41 ; JP1.3 120.93,14.48 ; JP1.3 118.88,15.36 ; JP1.3 118.59,14.48 ; JP1.3 119.76,15.65 ; JP1.3 120.64,15.36 ; JP1.3 118.88,13.6 ; JP1.3 120.64,13.6 ; JP1.3 119.76,13.31 ; 15.91,6.45 J15.2 ; J15.2 17.36,4.01 ; J15.2 17.36,8.89 ; J15.2 15.91,4.01 ; J15.2 18.81,8.89 ; J15.2 15.91,8.89 ; J15.2 18.81,6.45 ; 11.22,1.7 MT2.1 ; MT2.1 12.7,5.19 ; MT2.1 10.68,3.17 ; MT2.1 11.22,4.65 ; MT2.1 14.72,3.17 ; MT2.1 14.18,1.7 ; MT2.1 14.18,4.65 ; MT2.1 12.7,1.16 ; 113,47.81 J14.5 ; J14.5 111.34,49.48 ; J14.5 114.67,49.48 ; J14.5 113,51.14 ; J14.5 111.78,48.25 ; J14.5 114.23,50.71 ; J14.5 114.23,48.25 ; J14.5 111.78,50.71 ; J13.4 119.31,61.5 ; J13.4 118.08,58.61 ; J13.4 116.42,60.27 ; J13.4 119.31,59.05 ; J13.4 116.86,59.05 ; J13.4 118.08,61.94 ; J13.4 116.86,61.5 ; J13.4 119.75,60.27
  L4_SIG w0.432: 56.7,65.66 J7.3 ; J7.3 58.37,63.99 ; J7.3 57.14,64.43 ; J7.3 58.37,67.32 ; J7.3 59.6,64.43 ; J7.3 59.6,66.89 ; J7.3 57.14,66.89 ; J7.3 60.03,65.66 ; TP29.1 75.95,6.5 ; TP29.1 73.81,7.42 ; TP29.1 73.81,5.59 ; TP29.1 75.64,5.59 ; TP29.1 73.51,6.5 ; TP29.1 75.64,7.42 ; TP29.1 74.73,5.28 ; MT2.1 14.18,1.7 ; MT2.1 14.72,3.17 ; MT2.1 12.7,5.19 ; MT2.1 10.68,3.17 ; MT2.1 12.7,1.16 ; MT2.1 11.22,1.7 ; MT2.1 14.18,4.65 ; MT2.1 11.22,4.65 ; 51.62,65.66 J7.2 ; J7.2 52.06,66.89 ; J7.2 53.29,67.32 ; J7.2 54.52,66.89 ; J7.2 53.29,63.99 ; J7.2 54.95,65.66 ; J7.2 52.06,64.43 ; J7.2 54.52,64.43 ; 90.09,14.22 J38.2 ; J38.2 92.43,14.22 ; J38.2 90.38,15.1 ; J38.2 92.14,15.1 ; J38.2 92.14,13.35 ; J38.2 90.38,13.35 ; J38.2 91.26,15.39 ; 111.34,65.35 J13.2 ; J13.2 114.23,64.13 ; J13.2 113,67.02 ; J13.2 111.78,64.13 ; J13.2 114.67,65.35 ; J13.2 111.78,66.58 ; J13.2 113,63.69 ; J13.2 114.23,66.58 ; 18.61,1.41 J15.3 ; J15.3 18.61,3.85 ; J15.3 21.51,6.29 ; J15.3 20.06,6.29 ; J15.3 21.51,3.85 ; J15.3 21.51,1.41 ; J15.3 20.06,1.41 ; 52.06,61.81 J7.5 ; J7.5 54.95,60.58 ; J7.5 53.29,58.91 ; J7.5 54.52,59.35 ; J7.5 54.52,61.81 ; J7.5 53.29,62.24 ; J7.5 51.62,60.58 ; J7.5 52.06,59.35 ; 111.34,54.56 J14.2 ; J14.2 114.23,53.33 ; J14.2 113,52.89 ; J14.2 111.78,55.79 ; J14.2 111.78,53.33 ; J14.2 114.23,55.79 ; J14.2 114.67,54.56 ; J14.2 113,56.22 ; 89.51,23.52 TP31.1 ; TP31.1 89.51,21.69 ; TP31.1 91.64,22.61 ; TP31.1 91.34,23.52 ; TP31.1 89.2,22.61 ; TP31.1 90.42,23.83 ; TP31.1 90.42,21.39 ; TP31.1 91.34,21.69 ; 118.59,14.48 JP1.3 ; JP1.3 119.76,13.31 ; JP1.3 120.64,13.6 ; JP1.3 118.88,13.6 ; JP1.3 119.76,15.65 ; JP1.3 118.88,15.36 ; JP1.3 120.64,15.36 ; JP1.3 120.93,14.48 ; J15.2 18.81,8.89 ; J15.2 15.91,4.01 ; J15.2 17.36,4.01 ; J15.2 15.91,6.45 ; J15.2 18.81,6.45 ; J15.2 17.36,8.89 ; J15.2 15.91,8.89 ; 116.42,49.48 J14.4 ; J14.4 116.86,48.25 ; J14.4 119.75,49.48 ; J14.4 116.86,50.71 ; J14.4 119.31,50.71 ; J14.4 118.08,47.81 ; J14.4 119.31,48.25 ; J14.4 118.08,51.14 ; TP18.1 30.19,5.45 ; TP18.1 29.01,5.87 ; TP18.1 27.82,3.08 ; TP18.1 30.19,3.08 ; TP18.1 30.61,4.27 ; TP18.1 27.82,5.45 ; TP18.1 27.41,4.27 ; TP18.1 29.01,2.67 ; 116.86,53.33 J14.3 ; J14.3 118.08,56.22 ; J14.3 119.31,55.79 ; J14.3 119.31,53.33 ; J14.3 118.08,52.89 ; J14.3 116.42,54.56 ; J14.3 119.75,54.56 ; J14.3 116.86,55.79 ; J13.5 114.23,59.05 ; J13.5 113,61.94 ; J13.5 111.78,59.05 ; J13.5 111.78,61.5 ; J13.5 114.67,60.27 ; J13.5 114.23,61.5 ; J13.5 111.34,60.27 ; J13.5 113,58.61 ; 113,47.81 J14.5 ; J14.5 111.78,48.25 ; J14.5 111.34,49.48 ; J14.5 114.23,48.25 ; J14.5 111.78,50.71 ; J14.5 114.23,50.71 ; J14.5 114.67,49.48 ; J14.5 113,51.14 ; TP21.1 59.03,21.13 ; TP21.1 59.33,22.05 ; TP21.1 58.12,20.83 ; TP21.1 57.2,21.13 ; TP21.1 56.9,22.05 ; 19.57,65.41 MT1.1 ; MT1.1 20.11,63.93 ; MT1.1 21.59,67.42 ; MT1.1 20.11,66.88 ; MT1.1 23.07,66.88 ; MT1.1 23.07,63.93 ; MT1.1 21.59,63.39 ; MT1.1 23.61,65.41 ; J13.4 119.31,59.05 ; J13.4 118.08,61.94 ; J13.4 116.86,61.5 ; J13.4 119.31,61.5 ; J13.4 119.75,60.27 ; J13.4 116.42,60.27 ; J13.4 118.08,58.61 ; J13.4 116.86,59.05 ; JP3.2 27.51,64.52 ; JP3.2 28.68,63.35 ; JP3.2 28.39,62.47 ; JP3.2 27.51,62.18 ; JP3.2 28.39,64.22 ; JP2.1 33.4,67.39 ; JP2.1 34.28,67.1 ; JP2.1 34.28,65.34 ; JP2.1 33.4,65.05 ; JP2.1 32.52,65.34 ; JP2.1 34.57,66.22 ; JP2.1 32.23,66.22 ; JP2.1 32.52,67.1 ; J13.3 119.75,65.35 ; J13.3 119.31,66.58 ; J13.3 116.86,64.13 ; J13.3 116.86,66.58 ; J13.3 119.31,64.13 ; J13.3 116.42,65.35 ; J13.3 118.08,67.02 ; J13.3 118.08,63.69 ; 108.18,25.25 TP19.1 ; TP19.1 110.01,27.08 ; TP19.1 109.09,27.38 ; TP19.1 110.01,25.25 ; TP19.1 108.18,27.08 ; TP19.1 110.31,26.16 ; TP19.1 109.09,24.94 ; TP19.1 107.87,26.16 ; 41.38,15.72 TP27.1 ; TP27.1 41.1,16.13 ; TP27.1 41.07,16.64 ; TP27.1 41.1,17.15 ; 57.14,59.35 J7.4 ; J7.4 58.37,62.24 ; J7.4 56.7,60.58 ; J7.4 57.14,61.81 ; J7.4 60.03,60.58 ; J7.4 59.6,59.35 ; J7.4 59.6,61.81 ; J7.4 58.37,58.91
  L5_GND w0.432: 111.78,48.25 J14.5 ; J14.5 114.67,49.48 ; J14.5 111.34,49.48 ; J14.5 113,51.14 ; J14.5 111.78,50.71 ; J14.5 114.23,50.71 ; J14.5 114.23,48.25 ; J14.5 113,47.81 ; 89.51,21.69 TP31.1 ; TP31.1 90.42,23.83 ; TP31.1 91.34,21.69 ; TP31.1 89.2,22.61 ; TP31.1 91.64,22.61 ; TP31.1 89.51,23.52 ; TP31.1 90.42,21.39 ; TP31.1 91.34,23.52 ; 108.18,25.25 TP19.1 ; TP19.1 109.09,24.94 ; TP19.1 110.31,26.16 ; TP19.1 110.01,25.25 ; TP19.1 108.18,27.08 ; TP19.1 109.09,27.38 ; TP19.1 110.01,27.08 ; TP19.1 107.87,26.16 ; J14.2 114.23,53.33 ; J14.2 113,52.89 ; J14.2 111.78,55.79 ; J14.2 113,56.22 ; J14.2 111.78,53.33 ; J14.2 114.23,55.79 ; J14.2 114.67,54.56 ; J14.2 111.34,54.56 ; J13.4 118.08,61.94 ; J13.4 119.31,59.05 ; J13.4 118.08,58.61 ; J13.4 116.86,59.05 ; J13.4 116.42,60.27 ; J13.4 119.31,61.5 ; J13.4 116.86,61.5 ; J13.4 119.75,60.27 ; TP29.1 75.64,7.42 ; TP29.1 75.64,5.59 ; TP29.1 73.51,6.5 ; TP29.1 73.81,7.42 ; TP29.1 73.81,5.59 ; TP29.1 74.73,7.72 ; TP29.1 75.95,6.5 ; TP29.1 74.73,5.28 ; J13.5 113,61.94 ; J13.5 111.78,61.5 ; J13.5 111.34,60.27 ; J13.5 113,58.61 ; J13.5 114.23,61.5 ; J13.5 114.23,59.05 ; J13.5 111.78,59.05 ; J13.5 114.67,60.27 ; J7.2 54.95,65.66 ; J7.2 54.52,64.43 ; J7.2 53.29,63.99 ; J7.2 52.06,66.89 ; J7.2 52.06,64.43 ; J7.2 51.62,65.66 ; J7.2 54.52,66.89 ; J7.2 53.29,67.32 ; 18.61,1.41 J15.3 ; J15.3 20.06,6.29 ; J15.3 21.51,3.85 ; J15.3 21.51,1.41 ; J15.3 21.51,6.29 ; J15.3 18.61,3.85 ; J15.3 20.06,1.41 ; J14.4 119.31,50.71 ; J14.4 116.86,50.71 ; J14.4 119.75,49.48 ; J14.4 116.86,48.25 ; J14.4 118.08,47.81 ; J14.4 119.31,48.25 ; J14.4 118.08,51.14 ; J14.4 116.42,49.48 ; 56.7,60.58 J7.4 ; J7.4 59.6,59.35 ; J7.4 58.37,62.24 ; J7.4 59.6,61.81 ; J7.4 60.03,60.58 ; J7.4 58.37,58.91 ; J7.4 57.14,61.81 ; J7.4 57.14,59.35 ; JP3.2 28.68,63.35 ; JP3.2 28.39,62.47 ; JP3.2 26.63,62.47 ; JP3.2 28.39,64.22 ; JP3.2 27.51,64.52 ; JP3.2 26.63,64.22 ; JP3.2 27.51,62.18 ; JP3.2 26.34,63.35 ; TP18.1 29.01,5.87 ; TP18.1 29.01,2.67 ; TP18.1 27.82,3.08 ; TP18.1 27.82,5.45 ; TP18.1 30.61,4.27 ; TP18.1 30.19,3.08 ; TP18.1 30.19,5.45 ; TP18.1 27.41,4.27 ; 56.9,22.05 TP21.1 ; TP21.1 58.12,23.27 ; TP21.1 58.12,20.83 ; TP21.1 59.33,22.05 ; TP21.1 57.2,21.13 ; TP21.1 59.03,21.13 ; TP21.1 59.03,22.96 ; TP21.1 57.2,22.96 ; 15.91,8.89 J15.2 ; J15.2 17.36,8.89 ; J15.2 15.91,6.45 ; J15.2 15.91,4.01 ; J15.2 17.36,4.01 ; J15.2 18.81,8.89 ; J15.2 18.81,6.45 ; MT1.1 23.07,63.93 ; MT1.1 20.11,63.93 ; MT1.1 23.07,66.88 ; MT1.1 21.59,67.42 ; MT1.1 21.59,63.39 ; MT1.1 20.11,66.88 ; MT1.1 23.61,65.41 ; MT1.1 19.57,65.41 ; J38.2 91.26,15.39 ; J38.2 91.26,13.06 ; J38.2 90.09,14.22 ; J38.2 92.43,14.22 ; J38.2 92.14,13.35 ; J38.2 90.38,15.1 ; J38.2 92.14,15.1 ; J38.2 90.38,13.35 ; 119.76,13.31 JP1.3 ; JP1.3 119.76,15.65 ; JP1.3 120.64,13.6 ; JP1.3 120.93,14.48 ; JP1.3 118.88,15.36 ; JP1.3 120.64,15.36 ; JP1.3 118.59,14.48 ; JP1.3 118.88,13.6 ; 33.4,65.05 JP2.1 ; JP2.1 32.52,67.1 ; JP2.1 34.57,66.22 ; JP2.1 32.52,65.34 ; JP2.1 32.23,66.22 ; JP2.1 33.4,67.39 ; JP2.1 34.28,67.1 ; JP2.1 34.28,65.34 ; 116.42,54.56 J14.3 ; J14.3 118.08,56.22 ; J14.3 119.31,55.79 ; J14.3 119.31,53.33 ; J14.3 119.75,54.56 ; J14.3 118.08,52.89 ; J14.3 116.86,55.79 ; J14.3 116.86,53.33 ; 11.22,4.65 MT2.1 ; MT2.1 12.7,5.19 ; MT2.1 14.72,3.17 ; MT2.1 14.18,1.7 ; MT2.1 10.68,3.17 ; MT2.1 12.7,1.16 ; MT2.1 14.18,4.65 ; MT2.1 11.22,1.7 ; TP27.1 42.29,17.86 ; TP27.1 42.29,15.42 ; TP27.1 43.2,17.55 ; TP27.1 41.07,16.64 ; TP27.1 41.38,17.55 ; TP27.1 43.51,16.64 ; TP27.1 43.2,15.72 ; TP27.1 41.38,15.72 ; 111.78,66.58 J13.2 ; J13.2 114.67,65.35 ; J13.2 111.78,64.13 ; J13.2 111.34,65.35 ; J13.2 113,63.69 ; J13.2 114.23,64.13 ; J13.2 113,67.02 ; J13.2 114.23,66.58 ; J7.3 60.03,65.66 ; J7.3 58.37,67.32 ; J7.3 59.6,66.89 ; J7.3 56.7,65.66 ; J7.3 58.37,63.99 ; J7.3 57.14,64.43 ; J7.3 59.6,64.43 ; J7.3 57.14,66.89 ; 53.29,58.91 J7.5 ; J7.5 53.29,62.24 ; J7.5 54.52,61.81 ; J7.5 54.95,60.58 ; J7.5 54.52,59.35 ; J7.5 52.06,59.35 ; J7.5 51.62,60.58 ; J7.5 52.06,61.81 ; J13.3 119.31,64.13 ; J13.3 116.42,65.35 ; J13.3 118.08,67.02 ; J13.3 119.75,65.35 ; J13.3 119.31,66.58 ; J13.3 118.08,63.69 ; J13.3 116.86,66.58 ; J13.3 116.86,64.13
  L6_PWR w0.432: 91.26,13.06 J38.2 ; J38.2 90.38,13.35 ; J38.2 90.09,14.22 ; J38.2 90.38,15.1 ; J38.2 91.26,15.39 ; J38.2 92.14,15.1 ; J38.2 92.43,14.22 ; J38.2 92.14,13.35 ; 18.61,1.41 J15.3 ; J15.3 21.51,3.85 ; J15.3 21.51,1.41 ; J15.3 20.06,1.41 ; J15.3 18.61,3.85 ; J15.3 21.51,6.29 ; J15.3 20.06,6.29 ; J7.4 59.6,59.35 ; J7.4 56.7,60.58 ; J7.4 60.03,60.58 ; J7.4 58.37,62.24 ; J7.4 57.14,59.35 ; J7.4 57.14,61.81 ; J7.4 58.37,58.91 ; J7.4 59.6,61.81 ; 119.76,13.31 JP1.3 ; JP1.3 120.93,14.48 ; JP1.3 118.88,15.36 ; JP1.3 120.64,15.36 ; JP1.3 118.59,14.48 ; JP1.3 118.88,13.6 ; JP1.3 120.64,13.6 ; JP1.3 119.76,15.65 ; TP29.1 74.73,7.72 ; TP29.1 75.95,6.5 ; TP29.1 73.81,5.59 ; TP29.1 75.64,7.42 ; TP29.1 74.73,5.28 ; TP29.1 73.51,6.5 ; TP29.1 73.81,7.42 ; TP29.1 75.64,5.59 ; 26.34,63.35 JP3.2 ; JP3.2 26.63,64.22 ; JP3.2 28.39,64.22 ; JP3.2 27.51,62.18 ; JP3.2 28.68,63.35 ; JP3.2 27.51,64.52 ; JP3.2 28.39,62.47 ; JP3.2 26.63,62.47 ; 32.52,65.34 JP2.1 ; JP2.1 33.4,67.39 ; JP2.1 34.28,67.1 ; JP2.1 33.4,65.05 ; JP2.1 34.28,65.34 ; JP2.1 32.52,67.1 ; JP2.1 34.57,66.22 ; JP2.1 32.23,66.22 ; 116.86,61.5 J13.4 ; J13.4 119.75,60.27 ; J13.4 119.31,59.05 ; J13.4 118.08,61.94 ; J13.4 119.31,61.5 ; 89.51,23.52 TP31.1 ; TP31.1 90.42,21.39 ; TP31.1 91.64,22.61 ; TP31.1 91.34,21.69 ; TP31.1 91.34,23.52 ; TP31.1 89.51,21.69 ; TP31.1 90.42,23.83 ; 15.91,8.89 J15.2 ; J15.2 17.36,8.89 ; J15.2 17.36,4.01 ; J15.2 18.81,8.89 ; J15.2 15.91,6.45 ; J15.2 15.91,4.01 ; J15.2 18.81,6.45 ; J13.2 114.67,65.35 ; J13.2 113,67.02 ; J13.2 114.23,64.13 ; J13.2 111.78,66.58 ; J13.2 114.23,66.58 ; J7.2 54.52,66.89 ; J7.2 52.06,64.43 ; J7.2 52.06,66.89 ; J7.2 53.29,63.99 ; J7.2 51.62,65.66 ; J7.2 53.29,67.32 ; J7.2 54.52,64.43 ; J7.2 54.95,65.66 ; 53.29,58.91 J7.5 ; J7.5 52.06,61.81 ; J7.5 54.95,60.58 ; J7.5 54.52,61.81 ; J7.5 53.29,62.24 ; J7.5 54.52,59.35 ; J7.5 51.62,60.58 ; J7.5 52.06,59.35 ; MT1.1 23.61,65.41 ; MT1.1 20.11,66.88 ; MT1.1 19.57,65.41 ; MT1.1 20.11,63.93 ; MT1.1 21.59,63.39 ; MT1.1 23.07,66.88 ; MT1.1 21.59,67.42 ; MT1.1 23.07,63.93 ; J7.3 59.6,64.43 ; J7.3 59.6,66.89 ; J7.3 60.03,65.66 ; J7.3 58.37,67.32 ; J7.3 58.37,63.99 ; J7.3 57.14,66.89 ; J7.3 56.7,65.66 ; J7.3 57.14,64.43 ; J13.3 119.31,66.58 ; J13.3 116.86,66.58 ; J13.3 116.86,64.13 ; J13.3 119.31,64.13 ; J13.3 118.08,63.69 ; J13.3 118.08,67.02 ; J13.3 119.75,65.35 ; J13.3 116.42,65.35 ; MT2.1 14.18,4.65 ; MT2.1 14.72,3.17 ; MT2.1 10.68,3.17 ; MT2.1 11.22,1.7 ; MT2.1 11.22,4.65 ; MT2.1 12.7,1.16 ; MT2.1 12.7,5.19 ; MT2.1 14.18,1.7 ; TP18.1 29.01,5.87 ; TP18.1 27.41,4.27 ; TP18.1 27.82,3.08 ; TP18.1 27.82,5.45 ; TP18.1 29.01,2.67 ; TP18.1 30.19,3.08 ; TP18.1 30.61,4.27 ; TP18.1 30.19,5.45
  L7_GND w0.432: 111.78,66.58 J13.2 ; J13.2 114.23,64.13 ; J13.2 111.78,64.13 ; J13.2 113,63.69 ; J13.2 114.67,65.35 ; J13.2 113,67.02 ; J13.2 114.23,66.58 ; J13.2 111.34,65.35 ; J7.4 59.6,61.81 ; J7.4 57.14,61.81 ; J7.4 60.03,60.58 ; J7.4 56.7,60.58 ; J7.4 58.37,62.24 ; J7.4 57.14,59.35 ; J7.4 58.37,58.91 ; J7.4 59.6,59.35 ; 111.78,61.5 J13.5 ; J13.5 114.23,61.5 ; J13.5 113,58.61 ; J13.5 111.34,60.27 ; J13.5 111.78,59.05 ; J13.5 114.67,60.27 ; J13.5 114.23,59.05 ; J13.5 113,61.94 ; 116.86,61.5 J13.4 ; J13.4 116.42,60.27 ; J13.4 118.08,61.94 ; J13.4 119.31,59.05 ; J13.4 118.08,58.61 ; J13.4 116.86,59.05 ; J13.4 119.75,60.27 ; J13.4 119.31,61.5 ; J14.3 119.31,53.33 ; J14.3 118.08,56.22 ; J14.3 118.08,52.89 ; J14.3 116.86,55.79 ; J14.3 116.86,53.33 ; J14.3 119.31,55.79 ; J14.3 116.42,54.56 ; J14.3 119.75,54.56 ; 52.06,66.89 J7.2 ; J7.2 54.52,64.43 ; J7.2 51.62,65.66 ; J7.2 54.95,65.66 ; J7.2 52.06,64.43 ; J7.2 53.29,63.99 ; J7.2 53.29,67.32 ; J7.2 54.52,66.89 ; TP21.1 59.33,22.05 ; TP21.1 59.03,22.96 ; TP21.1 57.2,21.13 ; TP21.1 57.2,22.96 ; TP21.1 59.03,21.13 ; TP21.1 58.12,23.27 ; TP21.1 56.9,22.05 ; TP21.1 58.12,20.83 ; MT1.1 21.59,67.42 ; MT1.1 19.57,65.41 ; MT1.1 20.11,66.88 ; MT1.1 23.61,65.41 ; MT1.1 23.07,66.88 ; MT1.1 21.59,63.39 ; MT1.1 23.07,63.93 ; MT1.1 20.11,63.93 ; 53.29,58.91 J7.5 ; J7.5 51.62,60.58 ; J7.5 54.52,59.35 ; J7.5 53.29,62.24 ; J7.5 52.06,59.35 ; J7.5 52.06,61.81 ; J7.5 54.52,61.81 ; J7.5 54.95,60.58 ; TP19.1 110.31,26.16 ; TP19.1 110.01,27.08 ; TP19.1 108.18,27.08 ; TP19.1 109.09,27.38 ; TP19.1 108.18,25.25 ; TP19.1 110.01,25.25 ; TP19.1 109.09,24.94 ; TP19.1 107.87,26.16 ; 15.91,4.01 J15.2 ; J15.2 17.36,4.01 ; J15.2 15.91,6.45 ; J15.2 17.36,8.89 ; J15.2 18.81,6.45 ; J15.2 15.91,8.89 ; J15.2 18.81,8.89 ; 29.01,2.67 TP18.1 ; TP18.1 30.19,5.45 ; TP18.1 30.19,3.08 ; TP18.1 27.82,5.45 ; TP18.1 27.82,3.08 ; TP18.1 29.01,5.87 ; TP18.1 30.61,4.27 ; TP18.1 27.41,4.27 ; JP1.3 120.93,14.48 ; JP1.3 120.64,15.36 ; JP1.3 118.88,15.36 ; JP1.3 119.76,13.31 ; JP1.3 120.64,13.6 ; JP1.3 118.88,13.6 ; JP1.3 119.76,15.65 ; JP1.3 118.59,14.48 ; 74.73,5.28 TP29.1 ; TP29.1 73.51,6.5 ; TP29.1 74.73,7.72 ; TP29.1 73.81,7.42 ; TP29.1 75.64,5.59 ; TP29.1 75.64,7.42 ; TP29.1 75.95,6.5 ; TP29.1 73.81,5.59 ; J14.4 119.75,49.48 ; J14.4 118.08,51.14 ; J14.4 116.86,50.71 ; J14.4 119.31,50.71 ; J14.4 118.08,47.81 ; J14.4 116.42,49.48 ; J14.4 119.31,48.25 ; J14.4 116.86,48.25 ; J38.2 92.43,14.22 ; J38.2 91.26,13.06 ; J38.2 90.38,13.35 ; J38.2 91.26,15.39 ; J38.2 92.14,13.35 ; J38.2 92.14,15.1 ; J38.2 90.09,14.22 ; J38.2 90.38,15.1 ; 111.34,54.56 J14.2 ; J14.2 111.78,55.79 ; J14.2 114.23,55.79 ; J14.2 114.67,54.56 ; J14.2 113,56.22 ; J14.2 111.78,53.33 ; J14.2 113,52.89 ; J14.2 114.23,53.33 ; J7.3 58.37,67.32 ; J7.3 60.03,65.66 ; J7.3 58.37,63.99 ; J7.3 59.6,66.89 ; J7.3 59.6,64.43 ; J7.3 57.14,64.43 ; J7.3 56.7,65.66 ; J7.3 57.14,66.89 ; MT2.1 14.18,1.7 ; MT2.1 11.22,4.65 ; MT2.1 14.18,4.65 ; MT2.1 12.7,5.19 ; MT2.1 14.72,3.17 ; MT2.1 11.22,1.7 ; MT2.1 12.7,1.16 ; MT2.1 10.68,3.17 ; 20.06,1.41 J15.3 ; J15.3 20.06,6.29 ; J15.3 18.61,3.85 ; J15.3 18.61,1.41 ; J15.3 21.51,1.41 ; J15.3 21.51,3.85 ; J15.3 21.51,6.29 ; J14.5 114.23,50.71 ; J14.5 113,47.81 ; J14.5 111.78,50.71 ; J14.5 113,51.14 ; J14.5 111.78,48.25 ; J14.5 114.23,48.25 ; J14.5 111.34,49.48 ; J14.5 114.67,49.48 ; 32.52,67.1 JP2.1 ; JP2.1 32.52,65.34 ; JP2.1 33.4,67.39 ; JP2.1 32.23,66.22 ; JP2.1 34.28,67.1 ; JP2.1 34.28,65.34 ; JP2.1 34.57,66.22 ; JP2.1 33.4,65.05 ; TP31.1 90.42,23.83 ; TP31.1 91.34,23.52 ; TP31.1 89.2,22.61 ; TP31.1 90.42,21.39 ; TP31.1 89.51,21.69 ; TP31.1 91.64,22.61 ; TP31.1 89.51,23.52 ; TP31.1 91.34,21.69 ; J13.3 119.31,64.13 ; J13.3 118.08,67.02 ; J13.3 118.08,63.69 ; J13.3 119.31,66.58 ; J13.3 116.86,66.58 ; J13.3 119.75,65.35 ; J13.3 116.86,64.13 ; J13.3 116.42,65.35 ; 26.63,64.22 JP3.2 ; JP3.2 26.63,62.47 ; JP3.2 27.51,62.18 ; JP3.2 28.39,64.22 ; JP3.2 26.34,63.35 ; JP3.2 27.51,64.52 ; JP3.2 28.68,63.35 ; JP3.2 28.39,62.47 ; TP27.1 42.29,17.86 ; TP27.1 43.2,15.72 ; TP27.1 41.38,17.55 ; TP27.1 43.2,17.55 ; TP27.1 41.07,16.64 ; TP27.1 42.29,15.42 ; TP27.1 43.51,16.64 ; TP27.1 41.38,15.72
  BOTTOM w0.305: v1(79.48,47.12) 79.43,47.07 R70.2 ; v2(45.64,64.85) 45.64,65.46 45.67,65.48 ; C58.2 31.67,40.01 31.62,40.06 ; C86.1 86.02,63.02 C72.2 ; v2(45.64,64.11) 45.62,64.08 45.62,63.83 45.54,63.76 45.54,63.58 45.16,63.19 ; 45.16,63.19 v6(44.93,62.97) v6(43.92,61.95) U30.41 v6(43.92,60.93) 44.66,60.19 U30.13 ; 45.16,63.19 U30.2 ; 45.16,63.19 U30.39 45.16,65.23 45.41,65.48 45.67,65.48 ; U30.4 45.17,62.19 v6(44.93,61.95) ; v1(99.35,10.17) U31.7 97.5,10.17 v3(97.13,10.54) ; v1(86.59,63.07) 87.35,63.07 v1(87.43,63.14) 87.45,63.17 v1(88.15,63.17) ; C60.2 31.67,45.46 31.62,45.41 ; U30.14 44.16,59.68 v6(43.92,59.92) ; v1(77.18,49.69) 77.13,49.74 R63.2 ; v1(74.94,49.64) 74.99,49.69 R64.2 ; v1(71.28,16.54) U17.12 71.28,14.56 v3(71.23,14.51) ; 45.67,65.48 v1(45.69,65.51) ; R69.2 77.27,47.07 v1(77.22,47.12) ; U30.34 42.66,63.21 v6(42.9,62.97) ; v1(49.19,17.19) 49.22,17.21 U16.18 v3(51.43,17.21) ; v3(53.46,17.21) U16.8 v1(55.59,17.21) ; v1(44.04,52.91) 44.02,52.93 R192.1 ; v1(38.72,7.39) v1(39.19,7.39) ; v6(41.88,60.93) 41.63,61.19 U30.25 40.06,61.19 v2(40.03,61.16) ; U30.6 45.19,61.19 v6(44.93,60.93) ; 127.64,42.67 v3(127.05,43.26) ; v6(41.88,62.97) 41.22,63.63 41.22,63.93 41.16,64 U30.31 ; J10.D16 v3(130.77,40.81) ; v1(84.96,63.4) 85.24,63.4 85.48,63.17 v1(85.82,63.17) ; v3(108.79,8.33) 109.44,8.98 U12.7 v1(111.93,8.98)
  BOTTOM w0.381: v3(133.39,34.35) 132.72,35.03 v3(132.72,35.05) ; J10.J8 v3(125.81,49.58) J10.H9 ; v3(126.97,34.37) v3(127.64,35.03) 127.64,35.05 ; v1(129.62,45.87) 130.12,46.48 130.18,46.48 ; J10.A13 135.25,43.97 v3(135.76,44.48) ; J10.B11 J10.B10 ; J10.B10 v3(134.54,48.31) ; J10.B10 133.96,47.75 v3(133.4,48.31) ; v3(124.41,34.21) 125.09,34.9 v3(125.09,35.05) ; J10.K9 123.77,49.02 v1(123.14,49.66) ; J10.J5 125.09,54.13 v3(124.54,54.69) ; v3(128.24,38.33) 127.71,38.86 127.64,38.86 v3(126.97,38.2) J10.H18 ; J10.D10 131.5,47.75 v3(132.03,48.29) ; J10.D2 v3(132,58.47) ; 127.64,50.29 127.64,50.27 v3(128.24,49.66) ; v3(134.49,53.39) 133.99,52.88 J10.B6 ; v3(133.27,54.64) 132.74,54.1 J10.C5 ; J10.D7 v3(132.05,50.95) ; v3(129.46,37.01) 128.91,37.57 J10.F18 ; v3(123.22,38.18) 123.8,37.59 J10.K18 123.83,37.62 125.07,38.86 J10.J17 ; v3(130.18,35.05) v3(130.89,34.34) ; J10.B14 v3(134.57,42.09) ; 130.18,54.1 v3(131.11,53.16) J10.D6 ; J10.A16 v1(135.94,40.13) ; J10.B2 v3(134.54,58.47) ; v3(129.44,58.47) 128.91,57.94 J10.F2 ; J10.B15 133.96,41.4 v3(133.4,41.96) ; J10.K6 v1(123.29,53.37) ; J10.F3 128.93,56.64 v3(129.46,56.11) ; J10.B3 134.01,56.64 v3(134.49,56.16) ; J10.D3 v3(132,56.08) ; 130.18,38.86 130.18,38.84 v3(130.73,38.28) ; 31.62,40.06 v3(31.58,40.11) ; J10.A12 v3(135.89,45.21)
  BOTTOM w0.432: J15.2 18.81,6.45 ; J15.2 17.36,8.89 ; J15.2 15.91,8.89 ; J15.2 15.91,4.01 ; J15.2 15.91,6.45 ; J15.2 17.36,4.01 ; J15.2 18.81,8.89 ; 18.61,3.85 J15.3 ; J15.3 20.06,1.41 ; J15.3 21.51,3.85 ; J15.3 21.51,1.41 ; J15.3 18.61,1.41 ; J15.3 21.51,6.29 ; J15.3 20.06,6.29 ; 73.51,6.5 TP29.1 ; TP29.1 75.64,5.59 ; TP29.1 73.81,5.59 ; TP29.1 73.81,7.42 ; TP29.1 74.73,7.72 ; TP29.1 75.95,6.5 ; TP29.1 75.64,7.42 ; TP29.1 74.73,5.28 ; J14.3 119.31,55.79 ; J14.3 116.86,55.79 ; J14.3 119.75,54.56 ; J14.3 119.31,53.33 ; J14.3 116.42,54.56 ; J14.3 118.08,56.22 ; J14.3 116.86,53.33 ; 42.29,15.42 TP27.1 ; TP27.1 42.29,17.86 ; TP27.1 43.51,16.64 ; TP27.1 41.38,15.72 ; TP27.1 41.07,16.64 ; TP27.1 41.38,17.55 ; TP27.1 43.2,17.55 ; TP27.1 43.2,15.72 ; 57.2,21.13 TP21.1 ; TP21.1 59.03,21.13 ; TP21.1 58.12,23.27 ; TP21.1 58.12,20.83 ; TP21.1 59.03,22.96 ; TP21.1 56.9,22.05 ; TP21.1 59.33,22.05 ; TP21.1 57.2,22.96 ; 89.51,23.52 TP31.1 ; TP31.1 90.42,23.83 ; TP31.1 90.42,21.39 ; TP31.1 91.34,21.69 ; TP31.1 91.34,23.52 ; TP31.1 89.2,22.61 ; TP31.1 89.51,21.69 ; TP31.1 91.64,22.61 ; 56.7,65.66 J7.3 ; J7.3 59.6,66.89 ; J7.3 60.03,65.66 ; J7.3 58.37,67.32 ; J7.3 58.37,63.99 ; J7.3 59.6,64.43 ; J7.3 57.14,64.43 ; J7.3 57.14,66.89 ; 111.34,54.56 J14.2 ; J14.2 111.78,53.33 ; J14.2 114.23,55.79 ; J14.2 114.23,53.33 ; J14.2 113,56.22 ; J14.2 114.67,54.56 ; 32.23,65.05 JP2.1 ; JP2.1 33.4,67.39 ; JP2.1 34.57,67.39 ; JP2.1 32.23,66.22 ; JP2.1 34.57,66.22 ; JP2.1 32.23,67.39 ; JP2.1 33.4,65.05 ; JP2.1 34.57,65.05 ; 109.09,24.94 TP19.1 ; TP19.1 108.18,25.25 ; TP19.1 108.18,27.08 ; TP19.1 110.31,26.16 ; TP19.1 107.87,26.16 ; TP19.1 109.09,27.38 ; TP19.1 110.01,27.08 ; TP19.1 110.01,25.25 ; J13.5 114.23,61.5 ; J13.5 114.67,60.27 ; J13.5 113,58.61 ; J13.5 111.78,59.05 ; J13.5 114.23,59.05 ; J13.5 111.34,60.27 ; J13.5 111.78,61.5 ; J13.5 113,61.94 ; 111.34,49.48 J14.5 ; J14.5 111.78,48.25 ; J14.5 114.23,48.25 ; J14.5 113,47.81 ; J14.5 111.78,50.71 ; J14.5 114.67,49.48 ; 52.06,66.89 J7.2 ; J7.2 51.62,65.66 ; J7.2 54.52,66.89 ; J7.2 53.29,63.99 ; J7.2 54.95,65.66 ; J7.2 52.06,64.43 ; J7.2 53.29,67.32 ; J7.2 54.52,64.43 ; J7.4 58.37,62.24 ; J7.4 59.6,61.81 ; J7.4 58.37,58.91 ; J7.4 56.7,60.58 ; J7.4 60.03,60.58 ; J7.4 59.6,59.35 ; J7.4 57.14,61.81 ; J7.4 57.14,59.35 ; 29.01,2.67 TP18.1 ; TP18.1 30.61,4.27 ; TP18.1 27.82,3.08 ; TP18.1 30.19,3.08 ; TP18.1 27.82,5.45 ; TP18.1 30.19,5.45 ; TP18.1 29.01,5.87 ; TP18.1 27.41,4.27 ; 118.88,15.36 JP1.3 ; JP1.3 120.64,13.6 ; JP1.3 119.76,13.31 ; JP1.3 120.93,14.48 ; JP1.3 119.76,15.65 ; JP1.3 118.59,14.48 ; JP1.3 120.64,15.36 ; JP1.3 118.88,13.6 ; J38.2 92.14,13.35 ; J38.2 92.43,14.22 ; J38.2 90.38,15.1 ; J38.2 90.38,13.35 ; J38.2 90.09,14.22 ; J38.2 91.26,15.39 ; J38.2 92.14,15.1 ; J38.2 91.26,13.06 ; 118.08,58.61 J13.4 ; J13.4 116.86,59.05 ; J13.4 119.31,61.5 ; J13.4 118.08,61.94 ; J13.4 116.86,61.5 ; J13.4 119.75,60.27 ; J13.4 119.31,59.05 ; J13.4 116.42,60.27 ; J13.2 114.23,66.58 ; J13.2 114.67,65.35 ; J13.2 111.78,64.13 ; J13.2 111.34,65.35 ; J13.2 111.78,66.58 ; J13.2 114.23,64.13 ; J13.2 113,67.02 ; J13.2 113,63.69 ; 116.86,48.25 J14.4 ; J14.4 119.75,49.48 ; J14.4 118.08,47.81 ; J14.4 116.42,49.48 ; J14.4 119.31,50.71 ; J13.3 119.75,65.35 ; J13.3 118.08,67.02 ; J13.3 116.86,64.13 ; J13.3 119.31,64.13 ; J13.3 116.86,66.58 ; J13.3 119.31,66.58 ; J13.3 116.42,65.35 ; J13.3 118.08,63.69 ; 53.29,58.91 J7.5 ; J7.5 53.29,62.24 ; J7.5 52.06,59.35 ; J7.5 54.95,60.58 ; J7.5 52.06,61.81 ; J7.5 51.62,60.58 ; J7.5 54.52,61.81 ; J7.5 54.52,59.35 ; 26.63,62.47 JP3.2 ; JP3.2 26.34,63.35 ; JP3.2 26.63,64.22 ; JP3.2 28.68,63.35 ; JP3.2 27.51,64.52 ; JP3.2 27.51,62.18 ; JP3.2 28.39,62.47 ; JP3.2 28.39,64.22
  BOTTOM w0.483: v3(28.95,38.79) 28.95,38.79 29.39,38.53 ; 31.62,45.41 v3(31.58,45.37)
  BOTTOM w0.508: J10.D22 131.5,32.51 v3(132.11,33.12) ; v3(124.38,56.06) 123.83,56.62 v3(123.83,56.64) ; 127.64,55.37 127.66,55.37 v3(128.14,54.89) ; J10.H15 127.03,40.74 127,40.74 v3(126.97,40.72) ; R141.1 v1(57.55,15.11) ; v3(133.38,33.15) 133.99,32.54 J10.B22 ; J10.A21 v1(135.94,33.1) ; J10.K15 123.8,41.4 v3(123.57,41.63) ; J10.A20 v3(134.7,35.61) ; v3(124.49,39.5) 125.09,38.89 J10.J17
  vias: v1(0.61,64.06) v1(0.64,62.33) v1(0.61,53.92) v1(0.64,52.2) v1(0.64,0.64) v1(0.67,15.36) v1(0.67,12.82) v1(0.67,10.28) v1(0.67,7.74) v1(0.67,5.2) v1(0.81,23.39) v1(0.79,21.72) v1(0.91,43.89) v1(0.94,41.91) v1(1.04,33.63) v1(1.04,31.85) v1(1.65,53.92) v1(1.65,52.2) v1(1.96,64.08) v1(1.98,62.36) v1(2.29,23.39) v1(2.26,21.72) v1(2.54,0.64) v1(2.57,43.89) v1(2.59,41.91) v1(2.79,53.92) v1(2.79,52.2) v1(2.84,33.63) v1(2.84,31.85) v1(3.17,64.08) v1(3.2,62.36) v1(3.25,3.12) v1(3.63,11.4) v1(3.84,53.92) v1(3.86,52.17) v1(3.89,23.42) v1(3.86,21.74) v1(4.06,43.89) v1(4.09,41.91) v1(4.29,33.6) v1(4.29,31.83) v1(4.45,0.64) v1(4.47,64.08) v1(4.5,62.36) v1(4.83,54.25) v1(4.95,67.94) v1(4.95,52.35) v1(5.03,44.68) v1(5,20.98) v1(5.08,58.42) v1(5.13,29.44) v1(5.08,26.67) v1(5.08,17.78) v1(5.21,64.64) v1(5.16,42.42) v1(5.21,15.44) v1(5.18,6.45) v1(5.26,36.68) v1(5.38,33.12) v1(5.51,30.61) v1(5.59,62.71) v1(5.64,50.88) v1(5.64,22.76) v1(5.77,55.12) v1(5.77,46.51) v1(5.97,53.01) v1(6.05,42.85) v1(6.15,65.13) v1(6.1,44.98) v1(6.1,11.68) v1(6.35,63.37) v1(6.35,39.37) v1(6.35,34.29) v1(6.32,20.17) v1(6.35,0.64) v1(6.38,24.13) v1(6.5,29.59) v1(6.6,31.9) v1(6.71,56.11) v1(6.65,21.87) v1(6.86,67.94) v1(6.91,53.87) v1(7.09,44.96) v1(7.09,42.85) v1(7.14,12.52) v1(7.06,3.12) v1(7.39,65.25) v1(7.42,63.53) v1(7.62,60.96) v1(7.62,48.26) v1(7.59,30.89) v1(7.57,26.62) v1(7.85,54.86) v1(7.77,28.32) v1(7.9,57.3) v1(8,21.72) v1(7.98,20.04) v1(8.02,12.52) v1(8.23,45.06) v1(8.23,42.82) v1(8.46,41.4) v1(8.76,67.94) v1(8.94,65.28) v1(8.89,36.83) v1(8.89,31.75) v1(8.86,29.62) v1(8.89,24.13) v1(8.89,17.78) v1(8.92,12.52) v1(8.97,63.55) v1(9.04,58.45) v1(9.04,56.06) v1(9.05,41.39) v1(9.09,27) v1(9.5,45.06) v1(9.63,41.4) v1(9.6,21.72) v1(9.58,20.04) v1(9.65,42.82) v1(9.88,54.58) v1(10.13,59.56) v1(10.19,57.2) v1(10.16,50.22) v1(10.16,49.35) v1(10.19,47.75) v1(10.16,34.29) v1(10.19,28.3) v1(10.19,14.86) v1(10.31,46.63) v1(10.39,65.25) v1(10.41,63.53) v1(10.41,25.68) v1(10.67,67.94) v1(10.82,7.01) v1(10.92,12.4) v1(11.1,21.72) v1(11.07,20.04) v1(11.15,60.53) v1(11.28,58.32) v1(11.48,45.72) v1(11.51,26.97) v1(11.68,24.51) v1(11.81,65.25) v1(11.84,63.53) v1(11.94,61.24) v1(11.96,50.22) v1(11.99,49.4) v1(12.01,47.73) v1(12.29,59.28) v1(12.4,26.11) v1(12.47,21.82) v1(12.5,17.81) v1(12.57,67.94) v1(12.62,20.12) v1(12.7,55.88) v1(12.7,48.26) v1(12.73,44.7) v1(12.67,40.59) v1(12.7,36.83) v1(12.7,31.75) v1(12.7,27.94) v1(12.78,46.99) v1(12.95,61.52) v1(12.98,23.98) v1(13.11,59.84) v1(13.21,65.25) v1(13.23,63.53) v1(13.23,25.65) v1(13.51,43.1) v1(13.49,42.24) v1(13.46,22.07) v1(13.56,38.23) v1(13.84,59.21) v1(13.84,45.9) v1(13.94,37.13) v1(13.94,26.34) v1(13.92,20.45) v1(14,14.86) v1(14.17,63.27) v1(14.22,61.44) v1(14.33,24.16) v1(14.35,44.81) v1(14.4,40.56) v1(14.42,27.03) v1(14.35,22.56) v1(14.48,67.94) v1(14.45,65.05) v1(14.48,46.61) v1(14.63,7.01) v1(14.66,58.47) v1(14.78,37.49) v1(14.76,36.32) v1(14.76,34.98) v1(15.04,23.14) v1(15.11,60.58) v1(15.09,33.68) v1(15.06,20.98) v1(15.21,62.13) v1(15.24,43.13) v1(15.21,42.29) v1(15.24,30.48) v1(15.19,25.02) v1(15.44,64.36) v1(15.42,38.23) v1(15.37,27.56) v1(15.57,57.66) v1(15.75,40.56) v1(15.82,32.97) v1(15.9,61.37) v1(15.9,59.84) v1(15.88,47.57) v1(15.85,25.6) v1(15.93,24.03) v1(15.88,0.64) v1(16.08,44.78) v1(16.33,42.77) v1(16.31,21.82) v1(16.31,17.81) v1(16.38,67.94) v1(16.38,63.55) v1(16.51,56.69) v1(16.48,34.75) v1(16.46,28.68) v1(16.54,14.27) v1(16.54,11.23) v1(16.63,60.6) v1(16.59,32.18) v1(16.58,24.84) v1(16.71,26.14) v1(16.87,59.16) v1(16.99,38.86) v1(16.97,36.73) v1(17.14,46.35) v1(17.09,35.84) v1(17.07,34.21) v1(17.17,62.79) v1(17.17,25.73) v1(17.25,22.78) v1(17.27,59.61) v1(17.3,45.54) v1(17.4,65.53) v1(17.42,31.34) v1(17.4,29.62) v1(17.58,55.7) v1(17.6,39.67) v1(17.75,20.5) v1(17.78,0.64) v1(17.91,61.95) v1(17.88,58.22) v1(17.91,27.28) v1(17.96,33.5) v1(18.04,23.42) v1(18.11,16.54) v1(18.29,67.94) v1(18.26,58.6) v1(18.31,30.48) v1(18.29,26.87) v1(18.49,24.28) v1(18.64,60.96) v1(18.59,54.66) v1(18.59,11.15) v1(18.72,32.66) v1(19.18,44.48) v1(19.23,40.82) v1(19.28,35.56) v1(19.43,53.82) v1(19.63,31.85) v1(19.63,25.4) v1(19.71,59.94) v1(19.68,0.64) v1(19.76,22.99) v1(20.07,38.89) v1(20.07,36.6) v1(20.12,35.56) v1(20.32,62.23) v1(20.45,52.81) v1(20.37,33.78) v1(20.65,26.44) v1(20.75,58.9) v1(20.83,38.53) v1(20.98,35.71) v1(21.13,36.83) v1(21.08,33.53) v1(21.16,13.59) v1(21.16,11.86) v1(21.46,51.77) v1(21.51,27.28) v1(21.64,40.31) v1(21.62,33.78) v1(21.59,0.64) v1(21.74,57.91) v1(21.92,51.33) v1(22.12,35.53) v1(22.07,23.06) v1(22.2,37.34) v1(22.61,5.61) v1(22.67,53.82) v1(22.76,31.39) v1(22.89,28.7) v1(22.86,25.4) v1(23.22,35.66) v1(23.19,13.61) v1(23.29,11.86) v1(23.42,49.78) v1(23.55,21.44) v1(23.55,20.75) v1(23.55,18.19) v1(23.52,16.21) v1(23.5,0.64) v1(23.75,3.38) v1(23.93,57.45) v1(23.88,29.29) v1(24.03,55.65) v1(23.98,35.66) v1(24.05,33.02) v1(24.18,49.78) v1(24.21,21.42) v1(24.21,20.77) v1(24.21,18.17) v1(24.21,16.22) v1(24.36,35.05) v1(24.53,50.32) v1(24.64,62.94) v1(24.69,54.97) v1(24.94,59.56) v1(24.87,21.44) v1(24.87,20.75) v1(24.89,18.16) v1(24.89,16.21) v1(25.15,54.48) v1(25.15,29.26) v1(25.25,31.06) v1(25.33,13.62) v1(25.4,0.64) v1(25.68,11.86) v1(25.81,57.45) v1(25.83,18.47) v1(25.83,16.43) v1(25.91,67.94) v1(26.14,55.47) v1(26.37,53.16) v1(26.42,5.61) v1(26.42,2.57) v1(26.64,12.27) v1(26.67,32.99) v1(26.75,31.09) v1(26.75,29.29) v1(27.03,35) v1(27.2,56.62) v1(27.19,13.6) v1(27.26,50.91) v1(27.33,21.46) v1(27.33,20.4) v1(27.3,0.64) v1(27.36,54.13) v1(27.38,27.51) v1(27.63,23.11) v1(27.81,67.94) v1(27.94,25.4) v1(28.14,57.56) v1(28.35,29.29) v1(28.3,20.92) v1(28.42,55.19) v1(28.42,33.05) v1(28.4,31.09) v1(28.47,35) v1(28.63,12.22) v1(28.68,15.16) v1(28.79,50.93) v1(28.83,19.25) v1(29.06,58.47) v1(29.21,60.96) v1(29.24,20.37) v1(29.21,0.64) v1(29.26,21.49) v1(29.36,56.18) v1(29.72,67.94) v1(29.87,59.28) v1(30.12,55.63) v1(30.1,53.21) v1(30.33,57.12) v1(30.61,60.02) v1(30.61,35.56) v1(30.61,5.87) v1(30.84,49.78) v1(30.81,33.07) v1(30.78,18.82) v1(30.86,35) v1(30.86,31.09) v1(30.86,29.26) v1(31.09,57.89) v1(31.11,0.64) v1(31.37,56.31) v1(31.45,13.44) v1(31.45,18.84) v1(31.62,67.94) v1(31.62,60.81) v1(31.75,63.5) v1(31.75,25.4) v1(31.88,54.23) v1(31.9,35.03) v1(31.85,33.1) v1(31.9,31.11) v1(31.9,29.29) v1(32.03,58.55) v1(31.95,53.39) v1(32.11,18.82) v1(32.38,56.13) v1(32.37,50.06) v1(32.46,57.38) v1(32.64,50.94) v1(32.82,60.83) v1(32.79,59.03) v1(32.79,35.03) v1(32.87,27.28) v1(33.02,0.64) v1(33.3,33.1) v1(33.35,31.11) v1(33.35,29.29) v1(33.4,2.16) v1(33.53,67.94) v1(33.71,61.52) v1(33.68,58.27) v1(34.29,53.09) v1(34.34,51.03) v1(34.34,49.35) v1(34.37,61.01) v1(34.39,58.83) v1(34.37,42.67) v1(34.77,33.05) v1(34.82,31.06) v1(34.82,29.24) v1(34.77,21.23) v1(34.92,0.64) v1(34.98,58.45) v1(35.13,46.99) v1(35.13,44.83) v1(35.13,42.67) v1(35.13,40.51) v1(35.13,38.35) v1(35.15,36.2) v1(35.43,67.94) v1(35.38,27.33) v1(35.53,60.81) v1(35.59,57.91) v1(35.56,57.15) v1(35.61,56.34) v1(35.71,62.1) v1(35.79,55.37) v1(35.99,67.08) v1(35.99,65.96) v1(36.07,54) v1(36.11,25.98) v1(36.3,33.05) v1(36.35,31.06) v1(36.35,29.24) v1(36.4,18.92) v1(36.68,51.18) v1(36.68,49.23) v1(36.68,46.99) v1(36.68,44.81) v1(36.7,42.62) v1(36.7,40.54) v1(36.7,38.35) v1(36.7,36.2) v1(36.8,67.08) v1(36.8,65.96) v1(36.75,3.12) v1(36.83,0.64) v1(36.86,60.78) v1(36.91,59.05) v1(37.06,53.01) v1(37.08,11.81) v1(37.34,67.94) v1(37.41,62.66) v1(37.41,58.27) v1(37.39,57.07) v1(37.47,63.27) v1(37.52,62.15) v1(37.62,55.12) v1(37.64,5.16) v1(37.72,64.21) v1(37.74,59.92) v1(37.77,35.69) v1(37.82,33.05) v1(37.85,15.88) v1(37.95,52.15) v1(37.87,31.06) v1(37.87,29.24) v1(38.13,25.43) v1(38.18,40.54) v1(38.2,38.38) v1(38.33,54.89) v1(38.33,23.52) v1(38.25,7.39) v1(38.35,57.68) v1(38.48,47.02) v1(38.63,10.31) v1(38.66,53.98) v1(38.66,42.67) v1(38.73,0.64) v1(38.79,3.76) v1(38.86,57.18) v1(38.86,51.18) v1(38.91,49.17) v1(38.99,44.83) v1(39.01,35.05) v1(39.14,64.9) v1(39.14,54.58) v1(39.24,67.94) v1(39.34,58.06) v1(39.45,53.24) v1(39.37,20.32) v1(39.55,22.35) v1(39.57,40.54) v1(39.88,53.85) v1(39.98,58.45) v1(40.01,36.93) v1(40.28,52.4) v1(40.31,33.12) v1(40.34,29.29) v1(40.28,17.22) v1(40.26,12.55) v1(40.26,11.46) v1(40.39,64.54) v1(40.39,47.02) v1(40.36,31.06) v1(40.61,42.67) v1(40.64,13.97) v1(40.61,10.29) v1(40.64,0.64) v1(40.72,3.56) v1(40.69,2.77) v1(40.94,53.11) v1(41,49.1) v1(41.15,67.94) v1(41.25,38.96) v1(41.22,12) v1(41.27,3.17) v1(41.48,52.4) v1(41.48,51.18) v1(41.5,44.86) v1(41.81,35.15) v1(41.84,25.96) v1(41.84,21.08) v1(41.83,2.77) v1(41.88,55.47) v1(41.86,3.58) v1(41.99,65.81) v1(42.16,12.55) v1(42.16,11.48) v1(42.29,41.07) v1(42.52,54.56) v1(42.55,0.64) v1(42.57,66.5) v1(42.62,47.02) v1(42.67,55.47) v1(42.85,51.18) v1(42.93,37.21) v1(42.95,2.39) v1(43.05,67.94) v1(43.08,52.91) v1(43.23,67.16) v1(43.21,31.09) v1(43.18,29.29) v1(43.18,19.05) v1(43.28,43.1) v1(43.31,11.43) v1(43.36,33.1) v1(43.69,49.12) v1(43.81,46.28) v1(43.99,56.77) v1(44.09,55.7) v1(44.15,51.18) v1(44.07,39.32) v1(44.17,67.16) v1(44.27,35.15) v1(44.4,45.26) v1(44.45,22.86) v1(44.45,0.64) v1(44.75,57.05) v1(44.75,54.56) v1(44.81,15.01) v1(44.86,52.88) v1(44.96,67.94) v1(44.98,41.45) v1(45.09,67.16) v1(45.21,47.6) v1(45.47,59.39) v1(45.47,44.27) v1(45.64,56.64) v1(45.59,50.04) v1(45.59,20.68) v1(45.72,27.18) v1(45.72,25.4) v1(45.8,54.58) v1(45.8,52.88) v1(45.8,47.24) v1(46.13,67.03) v1(46.13,65.61) v1(46.1,19.94) v1(46.23,43.46) v1(46.28,37.19) v1(46.41,58.37) v1(46.35,0.64) v1(46.53,64.44) v1(46.46,21.84) v1(46.46,9.19) v1(46.63,33.1) v1(46.58,31.09) v1(46.63,29.31) v1(46.86,67.94) v1(46.91,67.08) v1(46.94,58.01) v1(46.94,48.69) v1(46.96,65.61) v1(46.96,54.61) v1(47.02,52.88) v1(47.02,39.29) v1(47.04,35.13) v1(46.99,24.26) v1(46.99,23.11) v1(46.96,8.46) v1(46.99,2.13) v1(47.29,41.35) v1(47.42,58.65) v1(47.37,56.72) v1(47.4,45.52) v1(47.52,26.34) v1(47.52,25.5) v1(47.75,64.49) v1(47.75,61.95) v1(47.83,60.83) v1(47.88,54.74) v1(48.21,6.5) v1(48.18,5.69) v1(48.29,57.51) v1(48.34,47.27) v1(48.31,25.91) v1(48.26,0.64) v1(48.41,67.03) v1(48.39,65.58) v1(48.41,52.98) v1(48.72,59.94) v1(48.74,37.16) v1(48.77,67.94) v1(48.77,60.83) v1(48.77,6.1) v1(48.9,64.47) v1(49.1,26.34) v1(49.1,25.5) v1(49.17,67.03) v1(49.25,65.58) v1(49.33,5.71) v1(49.4,61.72) v1(49.35,6.5) v1(49.45,53.59) v1(49.53,2.54) v1(49.63,60.83) v1(49.58,47.27) v1(49.61,45.44) v1(49.63,43.43) v1(49.61,41.33) v1(49.63,39.24) v1(49.66,49.53) v1(49.71,35.1) v1(49.73,32.99) v1(49.81,59.03) v1(49.83,56.72) v1(49.78,31.06) v1(49.83,29.26) v1(49.94,67.03) v1(49.91,26.62) v1(50.01,65.61) v1(50.01,64.49) v1(49.99,62.99) v1(49.99,61.93) v1(50.14,37.16) v1(50.24,54.38) v1(50.16,0.64) v1(50.67,67.94) v1(50.72,67.08) v1(51.03,55.17) v1(51.31,60.48) v1(51.41,65.61) v1(51.41,64.49) v1(51.44,62.99) v1(51.46,61.85) v1(51.46,5.23) v1(52.02,47.29) v1(52.04,45.47) v1(52.04,41.35) v1(52.07,43.46) v1(52.07,39.27) v1(52.12,37.24) v1(52.15,35.13) v1(52.07,0.64) v1(52.17,33.02) v1(52.22,31.09) v1(52.27,29.29) v1(52.37,58.8) v1(52.53,56.62) v1(52.58,67.94) v1(52.91,49.25) v1(53.29,58.78) v1(53.34,55.12) v1(53.34,51.56) v1(53.34,12.45) v1(53.34,2.54) v1(53.47,56.97) v1(53.75,11.18) v1(53.98,0.64) v1(54.23,6.99) v1(54.31,47.35) v1(54.33,45.52) v1(54.33,41.4) v1(54.43,58.85) v1(54.36,43.51) v1(54.36,39.32) v1(54.41,37.29) v1(54.43,35.18) v1(54.36,5.69) v1(54.48,67.94) v1(54.46,57) v1(54.46,33.07) v1(54.51,31.14) v1(54.46,10.03) v1(54.48,8.89) v1(54.56,29.34) v1(54.58,26.77) v1(54.61,24.13) v1(54.58,20.85) v1(54.74,49.53) v1(54.86,9.45) v1(55.17,52.91) v1(55.17,52.1) v1(55.22,13.46) v1(55.27,10.01) v1(55.27,8.86) v1(55.32,8.1) v1(55.42,58.83) v1(55.52,56.97) v1(55.83,60.43) v1(55.75,52.5) v1(55.88,0.64) v1(56.31,52.91) v1(56.29,52.15) v1(56.39,67.94) v1(56.57,58.83) v1(56.62,47.32) v1(56.64,45.49) v1(56.64,41.38) v1(56.64,8.89) v1(56.64,5.08) v1(56.67,56.97) v1(56.67,43.48) v1(56.67,39.29) v1(56.72,37.26) v1(56.74,35.15) v1(56.77,33.05) v1(56.82,31.11) v1(56.77,29.29) v1(57.51,64.11) v1(57.51,62.18) v1(57.55,18.94) v1(57.55,17.77) v1(57.55,16.63) v1(57.78,0.64) v1(57.91,12.7) v1(57.91,2.54) v1(58.01,52.93) v1(58.04,52.15) v1(58.12,58.78) v1(58.14,57) v1(58.29,67.94) v1(58.42,17.78) v1(58.6,52.53) v1(58.98,47.27) v1(59,45.44) v1(59.03,43.43) v1(59,41.33) v1(59.03,39.24) v1(59.08,37.21) v1(59.11,35.1) v1(59.13,32.99) v1(59.16,52.93) v1(59.18,52.12) v1(59.18,31.06) v1(59.23,29.26) v1(59.4,64.13) v1(59.36,58.85) v1(59.36,57) v1(59.51,62.15) v1(59.69,24.13) v1(59.69,0.64) v1(59.82,49.53) v1(59.79,20.83) v1(60.2,67.94) v1(60.17,16.71) v1(60.33,64.14) v1(60.3,9.96) v1(60.43,62.1) v1(60.43,59.26) v1(60.53,60.6) v1(60.58,57) v1(60.58,26.72) v1(60.71,2.97) v1(60.78,9.17) v1(60.88,52.91) v1(60.91,52.15) v1(60.96,66.04) v1(61.11,47.27) v1(61.14,45.44) v1(61.14,41.33) v1(61.16,43.43) v1(61.16,39.24) v1(61.21,37.21) v1(61.24,35.1) v1(61.26,32.99) v1(61.32,31.06) v1(61.42,64.16) v1(61.37,29.26) v1(61.47,52.53) v1(61.59,0.64) v1(62.03,52.91) v1(62.03,52.15) v1(62.1,67.94) v1(62.1,6.91) v1(62.08,6.1) v1(62.2,57) v1(62.23,21.59) v1(62.36,58.8) v1(62.46,60.6) v1(62.55,64.13) v1(62.56,62.13) v1(62.66,6.5) v1(62.84,47.27) v1(62.87,45.44) v1(62.89,43.43) v1(62.87,41.33) v1(62.89,39.24) v1(62.94,37.21) v1(62.97,35.1) v1(62.99,32.99) v1(63.04,31.06) v1(62.99,2.54) v1(63.09,29.26) v1(63.25,6.91) v1(63.22,6.12) v1(63.27,58.8) v1(63.4,57) v1(63.5,0.64) v1(63.83,52.15) v1(64.01,67.94) v1(64.11,63.96) v1(64.11,61.7) v1(64.22,65.35) v1(64.34,52.53) v1(64.29,35.13) v1(64.26,5.08) v1(64.47,59.13) v1(64.64,57) v1(64.69,47.29) v1(64.72,45.47) v1(64.74,43.46) v1(64.72,41.35) v1(64.74,39.27) v1(64.83,65.35) v1(64.8,37.24) v1(64.85,33.02) v1(64.77,24.13) v1(64.9,52.17) v1(64.9,49.53) v1(64.9,31.09) v1(64.95,29.29) v1(65.42,65.35) v1(65.38,60.05) v1(65.41,0.64) v1(65.56,63.93) v1(65.56,61.72) v1(65.68,57.81) v1(65.74,26.75) v1(65.71,7.62) v1(65.91,67.94) v1(66.24,47.24) v1(66.19,31.11) v1(66.24,15.52) v1(66.34,61.04) v1(66.29,53.98) v1(66.27,45.42) v1(66.29,43.41) v1(66.27,41.3) v1(66.29,39.22) v1(66.34,37.19) v1(66.42,29.29) v1(66.5,21.56) v1(66.65,58.8) v1(66.8,2.54) v1(66.9,63.93) v1(66.85,35.13) v1(67.03,61.72) v1(66.98,16.03) v1(66.98,8.03) v1(67.06,57.38) v1(67.23,55.65) v1(67.31,0.64) v1(67.41,64.08) v1(67.64,59.74) v1(67.82,67.94) v1(67.79,33.07) v1(67.77,30.18) v1(67.97,66.19) v1(68.01,64.08) v1(68.07,5.08) v1(68.2,47.27) v1(68.22,45.44) v1(68.25,43.43) v1(68.22,41.33) v1(68.25,39.24) v1(68.43,60.58) v1(68.61,64.08) v1(68.68,31.06) v1(68.91,37.16) v1(69.24,66.22) v1(69.19,61.34) v1(69.22,0.64) v1(69.27,64.52) v1(69.27,63.83) v1(69.42,59.84) v1(69.44,57.89) v1(69.72,67.94) v1(69.8,35.1) v1(69.9,55.6) v1(69.88,7.8) v1(69.98,62.08) v1(69.98,49.53) v1(70.48,62.66) v1(70.46,47.24) v1(70.48,45.42) v1(70.51,43.41) v1(70.48,41.3) v1(70.48,31.09) v1(70.61,33.02) v1(70.61,28.04) v1(70.61,16.69) v1(70.61,2.54) v1(70.82,65.53) v1(70.94,61.57) v1(71.04,39.29) v1(71.12,0.64) v1(71.32,62.97) v1(71.35,59.84) v1(71.63,67.94) v1(71.6,66.27) v1(71.93,37.19) v1(71.88,24.29) v1(71.88,8.89) v1(71.88,5.08) v1(72.06,63.02) v1(72.42,67.11) v1(72.52,47.29) v1(72.54,45.47) v1(72.57,43.46) v1(72.64,31.09) v1(72.72,35.1) v1(72.72,33.05) v1(72.82,63.17) v1(72.95,60.17) v1(73.03,26.21) v1(73.03,0.64) v1(73.1,41.33) v1(73.1,24.67) v1(73.53,67.94) v1(73.46,67.18) v1(73.48,61.87) v1(73.61,65.38) v1(73.69,63.22) v1(73.79,49.53) v1(73.96,47.9) v1(73.96,20.57) v1(74.07,59.36) v1(74.07,39.27) v1(74.27,24.69) v1(74.42,2.54) v1(74.5,67.13) v1(74.6,65.38) v1(74.63,45.49) v1(74.68,37.08) v1(74.73,35.13) v1(74.67,25) v1(74.78,64.67) v1(74.75,62.89) v1(74.75,33.05) v1(74.78,31.09) v1(74.93,49.02) v1(74.93,0.64) v1(75.05,25.28) v1(75.18,47.42) v1(75.23,43.43) v1(75.44,67.94) v1(75.51,67.28) v1(75.54,64.64) v1(75.51,62.89) v1(75.62,65.46) v1(75.97,20.4) v1(76,19.58) v1(76.12,41.33) v1(76.2,27.94) v1(76.38,16.28) v1(76.38,10.54) v1(76.61,5.18) v1(76.83,39.27) v1(76.83,37.16) v1(76.76,19.96) v1(76.83,0.64) v1(76.91,35.13) v1(76.89,33.05) v1(76.96,31.09) v1(77.14,45.47) v1(77.23,49.11) v1(77.34,67.94) v1(77.52,20.37) v1(77.52,19.56) v1(77.88,43.41) v1(78.23,6.35) v1(78.23,2.54) v1(78.74,29.39) v1(78.74,0.64) v1(78.94,64.44) v1(79.25,67.94) v1(79.25,50.42) v1(79.25,39.29) v1(79.35,45.49) v1(79.32,43.41) v1(79.3,41.3) v1(79.27,37.13) v1(79.3,35.13) v1(79.3,33.05) v1(79.32,31.04) v1(79.43,20.5) v1(79.46,49.11) v1(79.5,25.4) v1(79.5,22.86) v1(79.5,8.89) v1(80.26,67.41) v1(80.27,49.11) v1(80.29,47.45) v1(80.52,50.42) v1(80.64,0.64) v1(80.85,64.39) v1(81.15,67.94) v1(81.23,43.38) v1(81.2,41.27) v1(81.15,39.27) v1(81.18,37.11) v1(81.2,35.1) v1(81.2,33.02) v1(81.23,31.01) v1(81.18,6.81) v1(81.25,51.38) v1(81.25,45.47) v1(81.28,27.94) v1(81.28,19.05) v1(81.33,16.87) v1(81.28,13.97) v1(81.28,2.54) v1(82.5,67.41) v1(82.51,49.11) v1(82.55,0.64) v1(82.56,49.9) v1(82.65,47.29) v1(82.8,50.72) v1(83.06,67.94) v1(83.21,39.32) v1(83.24,37.16) v1(83.29,43.43) v1(83.26,41.33) v1(83.26,35.15) v1(83.26,33.07) v1(83.29,31.06) v1(83.77,45.44) v1(83.82,25.4) v1(84.07,11.4) v1(84.38,66.09) v1(84.35,11) v1(84.45,0.64) v1(84.58,51.33) v1(84.63,47.98) v1(84.61,17.48) v1(84.63,10.59) v1(84.61,4.27) v1(84.8,49.9) v1(84.79,49.12) v1(84.91,65.2) v1(84.96,67.94) v1(85.09,2.54) v1(85.29,47.24) v1(85.32,45.42) v1(85.34,43.41) v1(85.32,41.3) v1(85.34,39.22) v1(85.39,37.19) v1(85.42,35.08) v1(85.45,32.97) v1(85.5,31.04) v1(85.55,29.24) v1(85.82,65.4) v1(85.83,8.38) v1(85.83,7.54) v1(85.88,17.07) v1(86,59.26) v1(86.03,57.43) v1(86.11,53.47) v1(86.16,55.45) v1(86.26,47.75) v1(86.36,27.94) v1(86.39,7.95) v1(86.36,0.64) v1(86.87,67.94) v1(86.94,8.38) v1(86.94,7.54) v1(87.05,55.5) v1(87.02,53.75) v1(87.02,17.37) v1(87,16.54) v1(87.25,65.51) v1(87.4,47.24) v1(87.43,45.42) v1(87.43,41.3) v1(87.45,59.44) v1(87.45,57.2) v1(87.45,43.41) v1(87.45,39.22) v1(87.5,37.19) v1(87.53,35.08) v1(87.63,49.53) v1(87.55,32.97) v1(87.6,31.04) v1(87.78,16.97) v1(88.15,65.42) v1(88.27,0.64) v1(88.49,55.55) v1(88.54,17.37) v1(88.54,16.56) v1(88.58,53.23) v1(88.77,67.94) v1(88.9,25.4) v1(88.9,2.54) v1(88.95,59.41) v1(88.95,57.2) v1(89.31,47.24) v1(89.33,45.42) v1(89.33,41.3) v1(89.28,29.46) v1(89.36,43.41) v1(89.36,39.22) v1(89.41,37.19) v1(89.43,35.08) v1(89.46,52.02) v1(89.46,32.97) v1(89.51,31.04) v1(89.61,62.33) v1(89.74,18.19) v1(90.12,59.21) v1(90.09,57.4) v1(90.16,54.81) v1(90.17,5.08) v1(90.17,0.64) v1(90.4,65.53) v1(90.5,63.07) v1(90.6,15.77) v1(90.68,67.94) v1(90.65,51.28) v1(91.03,56.46) v1(91.21,47.24) v1(91.24,45.42) v1(91.24,41.3) v1(91.29,65.53) v1(91.29,63.07) v1(91.34,58.72) v1(91.26,43.41) v1(91.26,39.22) v1(91.31,37.19) v1(91.34,35.08) v1(91.44,60.96) v1(91.39,53.87) v1(91.36,32.97) v1(91.41,31.04) v1(91.44,27.94) v1(91.44,19.05) v1(91.41,9.47) v1(91.57,17.65) v1(91.57,16.64) v1(91.92,55.55) v1(91.9,53.21) v1(91.87,51.16) v1(92.05,65.56) v1(92.05,63.04) v1(92.08,0.64) v1(92.28,57.78) v1(92.46,17.65) v1(92.46,16.64) v1(92.58,67.94) v1(92.71,49.53) v1(92.76,65.43) v1(92.76,63.17) v1(92.84,54.64) v1(93.09,53.19) v1(93.07,51.13) v1(93.12,47.24) v1(93.14,45.42) v1(93.14,41.3) v1(93.17,56.87) v1(93.17,43.41) v1(93.17,39.22) v1(93.22,37.19) v1(93.24,35.08) v1(93.17,21.72) v1(93.27,32.97) v1(93.32,31.04) v1(93.55,65.2) v1(93.65,60.73) v1(93.68,63.25) v1(93.68,62.05) v1(93.68,59.26) v1(93.7,15.24) v1(93.7,13.97) v1(93.85,22.73) v1(93.98,2.54) v1(93.98,0.64) v1(94.08,55.96) v1(94.13,29.41) v1(94.31,57.89) v1(94.34,53.19) v1(94.31,51.13) v1(94.49,67.94) v1(94.74,64.72) v1(94.87,55.22) v1(94.92,53.42) v1(95.02,47.24) v1(95.05,45.42) v1(95.05,41.3) v1(95.07,43.41) v1(95.07,39.22) v1(95.12,37.19) v1(95.15,35.08) v1(95.17,32.97) v1(95.22,31.04) v1(95.48,63.27) v1(95.48,62.08) v1(95.45,60.76) v1(95.48,59.28) v1(95.48,57.3) v1(95.73,51.16) v1(95.76,53.21) v1(95.89,0.64) v1(96.09,4.24) v1(96.39,67.94) v1(96.37,60.2) v1(96.37,56.18) v1(96.39,55.22) v1(96.44,53.42) v1(96.52,27.94) v1(96.93,47.24) v1(96.95,45.42) v1(96.98,43.41) v1(96.95,41.3) v1(96.98,39.22) v1(97.03,37.19) v1(97.05,35.08) v1(97.08,32.97) v1(97.13,31.04) v1(97.18,63.58) v1(97.43,53.19) v1(97.41,51.13) v1(97.36,21.16) v1(97.79,49.53) v1(97.79,0.64) v1(98.09,14.4) v1(98.3,67.94) v1(98.3,55.22) v1(98.35,53.42) v1(98.83,47.24) v1(98.86,45.42) v1(98.88,43.41) v1(98.86,41.3) v1(98.88,39.22) v1(98.93,37.19) v1(99.03,63.47) v1(98.96,35.08) v1(98.98,32.97) v1(99.03,31.04) v1(99.06,5.08) v1(99.06,2.54) v1(99.39,53.19) v1(99.36,51.13) v1(99.52,19.18) v1(99.69,0.64) v1(99.8,8.23) v1(99.97,63.73) v1(100.2,67.94) v1(100.25,29.46) v1(100.33,12.7) v1(100.48,55.19) v1(100.53,53.39) v1(100.74,47.24) v1(100.76,45.42) v1(100.79,43.41) v1(100.76,41.3) v1(100.79,39.22) v1(100.84,37.19) v1(100.86,35.08) v1(100.89,32.97) v1(100.94,31.04) v1(101.09,63.73) v1(101.45,53.19) v1(101.42,51.13) v1(101.52,7.62) v1(101.6,66.04) v1(101.6,0.64) v1(101.78,4.04) v1(102.11,67.94) v1(102.21,63.73) v1(102.23,55.24) v1(102.29,53.44) v1(102.64,47.24) v1(102.57,25.78) v1(102.67,45.42) v1(102.69,43.41) v1(102.67,41.3) v1(102.69,39.22) v1(102.74,37.19) v1(102.77,35.08) v1(102.79,32.97) v1(102.84,31.04) v1(102.84,24.77) v1(102.87,49.53) v1(102.87,13.97) v1(103.05,53.19) v1(103.02,51.13) v1(103.25,23.5) v1(103.33,22.38) v1(103.33,21.56) v1(103.5,0.64) v1(103.76,55.22) v1(103.81,53.42) v1(103.89,22.38) v1(103.89,21.56) v1(103.91,7.57) v1(104.01,67.94) v1(104.14,27.94) v1(104.14,17.78) v1(104.14,2.54) v1(104.55,47.24) v1(104.6,63.47) v1(104.61,56.21) v1(104.57,45.42) v1(104.6,43.41) v1(104.57,41.3) v1(104.6,39.22) v1(104.65,37.19) v1(104.67,57.66) v1(104.75,51.13) v1(104.67,35.08) v1(104.7,32.97) v1(104.75,31.04) v1(104.78,53.19) v1(105.21,16.13) v1(105.18,15.01) v1(105.41,66.04) v1(105.41,24.13) v1(105.38,20.78) v1(105.41,0.64) v1(105.59,55.22) v1(105.64,53.42) v1(105.92,67.94) v1(106.07,16.13) v1(106.07,15.01) v1(106.45,47.24) v1(106.48,45.42) v1(106.5,43.41) v1(106.48,41.3) v1(106.5,39.22) v1(106.48,13.87) v1(106.48,12.75) v1(106.58,53.19) v1(106.55,51.13) v1(106.55,37.19) v1(106.58,35.08) v1(106.6,32.97) v1(106.65,31.04) v1(107.34,55.24) v1(107.31,0.64) v1(107.39,53.44) v1(107.44,29.51) v1(107.82,67.94) v1(107.83,56.21) v1(107.95,49.53) v1(107.95,20.32) v1(108.36,47.24) v1(108.38,45.42) v1(108.41,43.41) v1(108.38,41.3) v1(108.41,39.22) v1(108.48,53.19) v1(108.46,51.13) v1(108.46,37.19) v1(108.48,35.08) v1(108.51,32.97) v1(108.56,31.04) v1(108.79,56.18) v1(109.22,2.54) v1(109.22,0.64) v1(109.27,55.22) v1(109.32,53.42) v1(109.42,20.8) v1(109.42,19.99) v1(109.73,67.94) v1(110.03,22.07) v1(109.98,20.8) v1(109.98,19.99) v1(110.19,56.16) v1(110.26,53.64) v1(110.26,47.24) v1(110.29,45.42) v1(110.31,43.41) v1(110.29,41.3) v1(110.31,39.22) v1(110.31,13.03) v1(110.36,37.19) v1(110.39,35.08) v1(110.41,32.97) v1(110.49,66.04) v1(110.46,31.04) v1(110.49,27.94) v1(110.49,23.27) v1(110.69,24.21) v1(110.95,53.19) v1(110.92,51.13) v1(111.05,56.97) v1(111.12,0.64) v1(111.15,54.56) v1(111.51,5.99) v1(111.63,67.94) v1(111.76,3.81) v1(111.89,57.81) v1(112.17,47.24) v1(112.19,45.42) v1(112.22,43.41) v1(112.19,41.3) v1(112.22,39.22) v1(112.29,51.13) v1(112.27,37.19) v1(112.29,35.08) v1(112.32,32.97) v1(112.37,31.04) v1(113.03,11.43) v1(113.03,0.64) v1(113.11,58.39) v1(113.21,56.59) v1(113.54,67.94) v1(113.59,52.78) v1(114.05,27.91) v1(114.07,47.24) v1(114.1,45.42) v1(114.12,43.41) v1(114.1,41.3) v1(114.12,39.22) v1(114.17,37.19) v1(114.2,35.08) v1(114.22,32.97) v1(114.27,31.04) v1(114.3,25.4) v1(114.3,2.54) v1(114.81,61.16) v1(114.81,59.77) v1(114.83,58.42) v1(114.83,56.59) v1(114.83,54.94) v1(114.78,53.59) v1(114.94,0.64) v1(115.21,29.74) v1(115.44,67.94) v1(115.57,49.3) v1(115.57,16.51) v1(115.9,28.68) v1(115.98,47.24) v1(116,45.42) v1(116.03,43.41) v1(116,41.3) v1(116.03,39.22) v1(116.08,37.19) v1(116.1,35.08) v1(116.13,32.97) v1(116.18,31.04) v1(116.26,61.16) v1(116.28,59.77) v1(116.26,58.39) v1(116.26,56.59) v1(116.26,54.91) v1(116.26,53.57) v1(116.84,27.94) v1(116.84,8.89) v1(116.84,3.81) v1(116.84,0.64) v1(117.35,67.94) v1(117.3,52.68) v1(117.88,47.24) v1(117.91,45.42) v1(117.93,43.41) v1(117.91,41.3) v1(117.93,39.22) v1(117.98,37.19) v1(118.01,35.08) v1(118.03,32.97) v1(118.08,31.04) v1(118.11,22.86) v1(118.11,19.05) v1(118.11,11.43) v1(118.75,51.16) v1(118.75,0.64) v1(119.25,67.94) v1(119.38,25.4) v1(119.38,2.54) v1(119.46,46.05) v1(119.46,43.48) v1(119.63,53.24) v1(119.71,51.16) v1(119.84,33.02) v1(119.84,31.09) v1(119.91,41.38) v1(119.91,39.24) v1(119.91,37.19) v1(119.89,35.1) v1(119.86,7.62) v1(119.99,49.48) v1(120.65,62.23) v1(120.73,47.4) v1(120.65,44.5) v1(120.65,0.64) v1(121.16,67.94) v1(121.64,42.77) v1(121.64,37.16) v1(121.62,31.06) v1(121.56,12.85) v1(121.64,9.86) v1(121.67,53.26) v1(121.74,45.62) v1(121.67,39.8) v1(121.69,33.02) v1(121.82,51.18) v1(121.77,35.13) v1(121.92,48.62) v1(121.92,5.08) v1(122.12,21.01) v1(122.15,17.86) v1(122.2,23.39) v1(122.56,0.64) v1(122.73,38.02) v1(122.78,43.89) v1(122.78,41) v1(122.94,46.79) v1(122.94,31.06) v1(123.06,67.94) v1(123.14,35.69) v1(123.14,33.07) v1(123.6,7.85) v1(123.83,57.91) v1(123.83,45.21) v1(123.83,33.78) v1(123.83,29.97) v1(123.83,26.16) v1(123.83,22.35) v1(123.83,18.54) v1(123.83,14.73) v1(123.83,10.92) v1(124.46,2.54) v1(124.46,0.64) v1(124.74,63.27) v1(124.97,67.94) v1(125.09,55.37) v1(125.09,46.48) v1(125.09,42.67) v1(125.09,31.24) v1(125.09,27.43) v1(125.09,23.62) v1(125.09,19.81) v1(125.09,16) v1(125.09,12.19) v1(125.09,9.65) v1(126.36,52.83) v1(126.36,45.21) v1(126.36,33.78) v1(126.36,29.97) v1(126.36,26.16) v1(126.36,22.35) v1(126.36,18.54) v1(126.36,14.73) v1(126.36,10.92) v1(126.36,0.64) v1(126.67,60.02) v1(127.64,59.18) v1(127.64,54.1) v1(127.64,46.48) v1(127.64,31.24) v1(127.64,27.43) v1(127.64,23.62) v1(127.64,19.81) v1(127.64,16) v1(127.64,12.19) v1(127.64,9.65) v1(128.27,0.64) v1(128.55,63.27) v1(128.78,67.94) v1(128.91,52.83) v1(128.91,49.02) v1(128.91,45.21) v1(128.91,41.4) v1(128.91,33.78) v1(128.91,29.97) v1(128.91,26.16) v1(128.91,22.35) v1(128.91,18.54) v1(128.91,14.73) v1(128.91,10.92) v1(130.03,7.58) v1(130.18,59.18) v1(130.18,55.37) v1(130.18,50.29) v1(130.18,42.67) v1(130.18,31.24) v1(130.18,27.43) v1(130.18,23.62) v1(130.18,19.81) v1(130.18,16) v1(130.18,12.19) v1(130.18,9.65) v1(130.18,0.64) v1(130.68,67.94) v1(131.44,43.94) v1(131.44,36.32) v1(131.44,28.7) v1(131.44,24.89) v1(131.44,13.46) v1(131.44,10.92) v1(132.08,0.64) v1(132.52,63.31) v1(132.59,67.94) v1(132.59,3.91) v1(132.72,59.18) v1(132.72,55.37) v1(132.72,50.29) v1(132.72,49.02) v1(132.72,45.21) v1(132.72,43.94) v1(132.72,40.13) v1(132.72,38.86) v1(132.72,33.78) v1(132.72,29.97) v1(132.72,28.7) v1(132.72,24.89) v1(132.72,23.62) v1(132.72,19.81) v1(132.72,18.54) v1(132.72,14.73) v1(132.72,12.19) v1(132.72,9.65) v1(133.31,44.86) v1(133.3,44.33) v1(133.35,39.72) v1(133.49,38.34) v1(133.99,51.56) v1(133.99,37.59) v1(133.99,36.32) v1(133.99,31.24) v1(133.99,27.43) v1(133.99,26.16) v1(133.99,22.35) v1(133.99,21.08) v1(133.99,17.27) v1(133.99,16) v1(133.99,12.19) v1(133.99,10.92) v1(133.99,0.64) v1(134.29,60.71) v1(134.4,66.56) v1(134.49,67.94) v1(135.23,7.54) v1(135.25,59.18) v1(135.25,55.37) v1(135.25,54.1) v1(135.25,50.29) v1(135.25,49.02) v1(135.25,38.86) v1(135.25,29.97) v1(135.25,28.7) v1(135.25,24.89) v1(135.25,23.62) v1(135.25,19.81) v1(135.25,18.54) v1(135.25,14.73) v1(135.25,13.46) v1(135.25,9.65) v1(135.82,38.09) v1(135.8,35.82) v1(135.76,0.64) v1(135.87,40.96) v1(136.02,57.96) v1(135.99,56.62) v1(135.98,52.93) v1(135.97,51.37) v1(135.99,47.9) v1(135.96,46.66) v1(136.33,63.31) v1(136.4,67.94) v1(136.79,3.95) v1(137.41,0.64) v1(139.06,67.06) v1(139.06,64.14) v1(139.06,62.36) v1(139.06,60.33) v1(139.06,58.55) v1(139.06,56.52) v1(139.06,54.74) v1(139.06,52.7) v1(139.06,50.93) v1(139.06,48.9) v1(139.06,47.12) v1(139.06,45.09) v1(139.06,43.31) v1(139.06,41.27) v1(139.06,39.5) v1(139.06,37.47) v1(139.06,35.69) v1(139.06,33.66) v1(139.06,31.88) v1(139.06,29.84) v1(139.06,28.07) v1(139.06,26.04) v1(139.06,24.26) v1(139.06,22.23) v1(139.06,20.45) v1(139.06,16.64) v1(139.06,14.61) v1(139.06,12.83) v1(139.06,10.79) v1(139.06,9.02) v1(139.06,6.99) v1(139.06,5.21) v1(139.06,3.17) v1(139.06,0.64) v2(16.46,45.06) v2(16.54,42.01) v2(17.55,44.48) v2(17.63,43.51) v2(17.58,42.95) v2(18.03,41.88) v2(18.54,43.08) v2(18.49,41.83) v2(41.15,64.82) v2(41.15,64.47) v2(41.15,64.08) v2(42.65,64.82) v2(42.65,64.47) v2(42.65,64.08) v2(44.15,58.78) v2(44.15,58.42) v2(44.15,58.04) v2(44.65,58.78) v2(44.65,58.42) v2(44.65,58.04) v2(45.16,64.82) v2(45.16,64.47) v2(45.16,64.08) v2(45.64,64.49) v2(46.05,63.2) v2(46.05,62.18) v2(46.05,61.19) v2(46.43,63.2) v2(46.43,62.18) v2(46.43,61.19) v2(46.79,63.2) v2(46.79,62.18) v2(46.79,61.19) v3(0.51,67.65) v3(0.51,66.76) v3(0.51,65.87) v3(0.51,58.76) v3(0.51,57.49) v3(0.51,56.6) v3(0.51,55.71) v3(0.51,50.38) v3(0.51,49.49) v3(0.51,48.6) v3(0.51,47.33) v3(0.51,46.44) v3(0.51,45.55) v3(0.51,40.22) v3(0.51,39.33) v3(0.51,38.44) v3(0.51,37.17) v3(0.51,36.28) v3(0.51,35.39) v3(0.51,30.06) v3(0.51,29.17) v3(0.51,28.28) v3(0.51,27.01) v3(0.51,26.12) v3(0.51,25.23) v3(0.51,19.9) v3(0.51,19.01) v3(0.51,18.12) v3(1.27,67.65) v3(1.27,66.76) v3(1.27,65.87) v3(1.27,58.76) v3(1.27,57.49) v3(1.27,56.6) v3(1.27,55.71) v3(1.27,50.38) v3(1.27,49.49) v3(1.27,48.6) v3(1.27,47.33) v3(1.27,46.44) v3(1.27,45.55) v3(1.27,40.22) v3(1.27,39.33) v3(1.27,38.44) v3(1.27,37.17) v3(1.27,36.28) v3(1.27,35.39) v3(1.27,30.06) v3(1.27,29.17) v3(1.27,28.28) v3(1.27,27.01) v3(1.27,26.12) v3(1.27,25.23) v3(1.27,19.9) v3(1.27,19.01) v3(1.27,18.12) v3(1.45,16.13) v3(1.45,14.63) v3(1.45,7.24) v3(1.45,5.74) v3(1.46,15.37) v3(1.46,6.48) v3(2.03,67.65) v3(2.03,66.76) v3(2.03,65.87) v3(2.03,58.76) v3(2.03,57.49) v3(2.03,56.6) v3(2.03,55.71) v3(2.03,50.38) v3(2.03,49.49) v3(2.03,48.6) v3(2.03,47.33) v3(2.03,46.44) v3(2.03,45.55) v3(2.03,40.22) v3(2.03,39.33) v3(2.03,38.44) v3(2.03,37.17) v3(2.03,36.28) v3(2.03,35.39) v3(2.03,30.06) v3(2.03,29.17) v3(2.03,28.28) v3(2.03,27.01) v3(2.03,26.12) v3(2.03,25.23) v3(2.03,19.9) v3(2.03,19.01) v3(2.03,18.12) v3(2.41,16.13) v3(2.42,15.37) v3(2.41,14.63) v3(2.41,7.24) v3(2.42,6.48) v3(2.41,5.74) v3(2.79,67.65) v3(2.79,66.76) v3(2.79,65.87) v3(2.79,58.76) v3(2.79,57.49) v3(2.79,56.6) v3(2.79,55.71) v3(2.79,50.38) v3(2.79,49.49) v3(2.79,48.6) v3(2.79,47.33) v3(2.79,46.44) v3(2.79,45.55) v3(2.79,40.22) v3(2.79,39.33) v3(2.79,38.44) v3(2.79,37.17) v3(2.79,36.28) v3(2.79,35.39) v3(2.79,30.06) v3(2.79,29.17) v3(2.79,28.28) v3(2.79,27.01) v3(2.79,26.12) v3(2.79,25.23) v3(2.79,19.9) v3(2.79,19.01) v3(2.79,18.12) v3(3.38,16.13) v3(3.39,15.37) v3(3.38,14.63) v3(3.38,7.24) v3(3.39,6.48) v3(3.38,5.74) v3(3.56,67.65) v3(3.56,66.76) v3(3.56,65.87) v3(3.56,58.76) v3(3.56,57.49) v3(3.56,56.6) v3(3.56,55.71) v3(3.56,50.38) v3(3.56,49.49) v3(3.56,48.6) v3(3.56,47.33) v3(3.56,46.44) v3(3.56,45.55) v3(3.56,40.22) v3(3.56,39.33) v3(3.56,38.44) v3(3.56,37.17) v3(3.56,36.28) v3(3.56,35.39) v3(3.56,30.06) v3(3.56,29.17) v3(3.56,28.28) v3(3.56,27.01) v3(3.56,26.12) v3(3.56,25.23) v3(3.56,19.9) v3(3.56,19.01) v3(3.56,18.12) v3(6.93,16.13) v3(6.94,15.37) v3(6.93,14.63) v3(6.93,7.24) v3(6.94,6.48) v3(6.93,5.74) v3(7.9,16.13) v3(7.91,15.37) v3(7.9,14.63) v3(7.9,7.24) v3(7.91,6.48) v3(7.9,5.74) v3(8.86,16.13) v3(8.87,15.37) v3(8.86,14.63) v3(8.86,7.24) v3(8.87,6.48) v3(8.86,5.74) v3(23.69,45.37) v3(23.69,44.05) v3(23.69,42.74) v3(23.69,41.42) v3(23.69,40.11) v3(25.01,46.68) v3(25.01,44.05) v3(25.01,42.74) v3(25.01,41.42) v3(25.01,38.79) v3(26.32,46.68) v3(26.32,45.37) v3(26.32,42.74) v3(26.32,40.11) v3(26.32,38.79) v3(27.64,46.68) v3(27.64,45.37) v3(27.64,44.05) v3(27.64,41.42) v3(27.64,40.11) v3(27.64,38.79) v3(28.95,46.68) v3(28.95,45.37) v3(28.95,42.74) v3(28.95,40.11) v3(30.27,46.68) v3(30.27,44.05) v3(30.27,42.74) v3(30.27,41.42) v3(30.27,38.79) v3(31.58,44.05) v3(31.58,42.74) v3(31.58,41.42) v3(51.43,18.23) v3(52.44,18.23) v3(52.44,17.21) v3(52.44,16.2) v3(53.46,18.23) v3(53.46,16.2) v3(70.53,14.51) v3(70.53,13.81) v3(70.53,13.11) v3(70.53,12.41) v3(70.53,11.71) v3(71.23,13.81) v3(71.23,13.11) v3(71.23,12.41) v3(71.23,11.71) v3(71.93,14.51) v3(71.93,13.81) v3(71.93,13.11) v3(71.93,12.41) v3(71.93,11.71) v3(72.63,14.51) v3(72.63,13.81) v3(72.63,13.11) v3(72.63,12.41) v3(72.63,11.71) v3(73.33,14.51) v3(73.33,13.81) v3(73.33,13.11) v3(73.33,12.41) v3(73.33,11.71) v3(95.1,10.54) v3(95.1,9.53) v3(96.11,10.54) v3(96.11,9.53) v3(107.77,9.35) v3(107.77,8.33) v3(108.79,9.35) v3(109.8,9.35) v3(126.36,56.64) v4(76.86,59.39) v4(76.86,57.35) v4(76.86,56.34) v4(77.88,59.39) v4(77.88,58.37) v4(77.88,57.35) v4(77.88,56.34) v4(77.88,55.32) v4(78.9,60.4) v4(78.9,59.39) v4(78.9,58.37) v4(78.9,57.35) v4(78.9,56.34) v4(78.9,55.32) v4(79.91,60.4) v4(79.91,59.39) v4(79.91,58.37) v4(79.91,57.35) v4(79.91,56.34) v4(79.91,55.32) v4(80.93,60.4) v4(80.93,59.39) v4(80.93,58.37) v4(80.93,57.35) v4(80.93,56.34) v4(80.93,55.32) v4(80.93,54.31) v4(81.94,60.4) v4(81.94,59.39) v4(81.94,58.37) v4(81.94,57.35) v4(81.94,56.34) v4(81.94,55.32) v4(81.94,54.31) v4(82.96,60.4) v4(82.96,58.37) v4(82.96,57.35) v4(82.96,56.34) v4(82.96,55.32) v5(47.35,55.65) v5(47.35,51.82) v5(48.55,51.52) v5(48.97,55.96) v5(50.75,51.62) v5(51.69,55.78) v5(51.65,54.72) v5(51.65,52.72) v6(42.9,61.95) v6(42.9,60.93) v6(44.93,59.92)
