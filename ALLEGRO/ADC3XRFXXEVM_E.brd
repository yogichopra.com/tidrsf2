# Allegro board ADC3XRFXXEVM_E.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
N19887836 on L6_PWR: 75.56,62.87 75.56,52.07 80.64,52.07 80.64,62.87
N19887910 on TOP: 73.84,56.29 73.84,55.02 75.79,55.02 75.79,56.29
N19887912 on TOP: 73.61,54.38 73.61,53.16 75.69,53.16 75.69,54.38
N19887930 on TOP: 73.86,58.55 73.86,57.28 75.82,57.28 75.82,58.55
N20113513 on BOTTOM: 72.95,9.17 72.95,11.07 73.96,11.07 73.96,13.49 80.06,13.49 80.06,11.71 77.52,9.17
N20114896 on TOP: 85.12,15.82 85.12,9.47 89.05,9.47 89.05,15.82
N20114896 on BOTTOM: 83.46,5.66 83.46,14.55 84.73,15.82 88.67,15.82 89.05,15.44 89.05,6.55 87.15,4.65 84.48,4.65
N20121078 on BOTTOM: 78.41,14.25 78.41,16.03 77.52,16.92 74.09,16.92 74.09,18.95 78.79,18.95 80.7,17.04 80.7,14.25
N20220794 on TOP: 94.36,18.49 94.36,15.75 102.23,15.75 102.23,18.49
N20220794 on BOTTOM: 94.36,18.49 96.9,18.49 96.9,10.67 93.22,10.67 93.22,12.45 94.36,13.59

Small or netless copper shapes (teardrops, artwork): 2 on TOP

## Text on the board
BOTTOM: LAYER 8 (BOTTOM SIDE)
Board Geometry/Soldermask Bottom: SOLDERMASK BOTTOM
Ref Des/Silkscreen Bottom: SILKSCREEN BOTTOM
User.Comments: 1 | 2 | 3 | R57 | R177 | R178 | R184 | R175 | R176 | R179 | C400 | C410 | C409 | R59 | R58 | C403 | R192 | R187 | R191 | C412 | C413 | C432 | C431 | R189 | A1 | B1 | C1 | D1 | E1 | F1 | G1 | H1 | J1 | K1 | K36 | A40 | B40 | C40 | D40 | E40 | F40 | G40 | H40 | J40 | K40 | A6 | A11 | A16 | A21 | A26 | A31 | A36 | K6 | K11 | K16 | K21 | K26 | K31 | * | SJP2 | C157 | C158 | J38 | C156 | R152 | R151 | R85 | R84 | R87 | R86 | U30 | C385 | C388 | C389 | C170 | C171 | R53 | R52 | R51 | R180 | R50 | R67 | R181 | R70 | R68 | R69 | R63 | R47 | C70 | C74 | C73 | R64 | T6 | R56 | C394 | R174 | R182 | R186 | R183 | C420 | C188 | C187 | C186 | C185 | R185 | C28 | R75 | R79 | R164 | C67 | C69 | R48 | R49 | C419 | C418 | R66 | R65 | C75 | R55 | R60 | C395 | C421 | C47 | C45 | C44 | C428 | R165 | C8 | C9 | C38 | C39 | R188 | Y1 | U17 | AVDD1.9_ENB | U29 | U15 | HS1 | J5 | U12 | C163 | C160 | C162 | C161 | C159 | R80 | R72 | C84 | C81 | R54 | U31 | C71 | C85 | C82 | FAN POWER | U3 | R159 | R141 | R138 | R139 | R140 | R137 | C190 | C189 | C191 | U16 | C60 | C59 | C58 | U5 | T5 | R35 | R33 | FB16 | R81 | R73 | R71 | R76 | R82 | R74 | C72 | C83 | C86 | C386 | R158 | R145 | C193 | R143 | FB17 | C198 | C173 | R34 | R95 | FB12 | C104 | C103 | C197 | C194 | C195 | C196 | C122 | C126 | R157 | R133 | R77 | R78 | R40 | J11 | ADC CLK | INSTALL HEATSINK HS1 | ON BOTTOM SIDE OF BOARD | J10 | TEXAS INSTRUMENTS, INC. | PCB REV E | ADC3XRFXXEVM | 8MIL TRACE WIDTH AND 6MIL SPACING ON BOTTOM SIDE OF BOARD SHALL BE 100 OHMS DIFFERENTIAL +/- 10%. | TOP VIEW | BOTTOM VIEW
TOP: LAYER 1 (TOP SIDE)
Board Geometry/Soldermask Top: SOLDERMASK TOP
Ref Des/Silkscreen Top: CLK | EXT | ADC CLK IN | J5 | LMK SYNC | UL94V-0 | LOCKED | PCB REV E | ADC3XRFXX EVM | SILKSCREEN TOP
L2_GND: LAYER 2 - GND
L3_PWR: LAYER 3 - POWER
L4_SIG: LAYER 4 - GND
L5_GND: LAYER 5 - GND
L6_PWR: LAYER 6 - POWER/SIGNAL
L7_GND: LAYER 7 - GROUND
DIMENSION: PASTEMASK TOP
PLACE_BOUND_TOP: PASTEMASK BOTTOM
TOLERANCE_BOTTOM: SOLDERMASK TOP SOCKET BOARD
USER_PART_NUM_BOTTOM: PASTEMASK TOP SOCKET BOARD
User.11: 0.25oz / Plate to 0.5oz min Layer 6 | R-1775V | R-1650V | Core 0.008" | Copper Foil | Core 0.012" | Pre-preg 0.0042 | 0.5oz / 0.5oz Layer 5 & 6 | (material) | LAYER 7 | LAYER 8
User.12: 08-22-16 | 3. MARK BOARD'S SILKSCREEN WITH THE APPROPRIATE EVM PART NUMBER. | 4. IPC-A-610 / ACCEPTABILITY OF ELECTRONIC ASSEMBLIES, CLASS2, CURRENT REVISION. | 5. SOLDER FAN-SINK ASSEMBLY HS1 TO BOTTOM SIDE OF BOARD, UNDERNEATH U1.  CONNECT FAN TO FAN POWER J38.
User.21: FIGURE | SIZE | 6.0 | 8.0 | 10.0 | 12.0 | 13.0 | 15.0 | 38.0 | 40.0 | 62.0 | 67.0 | 106.0 | 125.0 | 35.0 | 50.0 | 118.11x39.37 | 137.8x39.37 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 167 | 2235 | 49 | 508 | 16 | 8 | 10 | 19 | 5 | 12 | 2 | 1
