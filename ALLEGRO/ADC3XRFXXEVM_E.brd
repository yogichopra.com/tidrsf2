# Allegro board ADC3XRFXXEVM_E.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1: length 34
  TOP w0.229: U33.1 v2(18.39,42.65) ; U32.1 18.38,45.85 v1(18.24,46)
  L4_SIG w0.127: JP3.1 26.29,64.67 26.29,61.44 25.7,60.86 24.69,60.86 24.18,60.35 v1(24.13,60.35) 23.55,60.35 14.68,51.48 14.68,48.11 15.99,46.8 17.44,46.8 v1(18.24,46) 18.16,45.92 18.16,44.98 18.36,44.78 18.36,44.68 18.38,44.67 18.38,43.8 18.9,43.28 18.9,42.9 18.65,42.65 v2(18.39,42.65)
V2: length 34.3
  TOP w0.203: v1(17.88,40.44) 18.03,40.59 U33.5
  TOP w0.229: U32.5 v2(18.03,42.95)
  L4_SIG w0.127: JP3.3 27.05,60.35 v1(25.27,60.35) 24.92,60.35 15.14,50.57 15.14,49.14 17.09,47.19 17.7,47.19 18.8,46.1 18.8,45.6 18.53,45.33 18.53,45.04 18.73,44.84 18.73,43.88 19.2,43.41 19.2,42.77 18.83,42.4 18.83,41.49 17.88,40.54 v1(17.88,40.44) 17.65,40.67 17.65,42.27 18.03,42.65 v2(18.03,42.95)
A_IN_M: length 14.8
  TOP w0.483: J2.1 3.82,22.57 arc(4.57,22.42) 5.21,21.99 5.66,21.54 arc(6.4,21.05) 7.26,20.88 11.6,20.88 arc(13.88,21.33) C415.1
A_IN_P: length 14.8
  TOP w0.483: J1.1 3.87,32.73 arc(4.53,32.6) 5.09,32.22 12.06,25.25 arc(12.57,24.91) 13.17,24.79 13.66,24.79 C414.1
ADC_CLK: length 4.3
  BOTTOM w0.483: J5.1 3.77,42.89 arc(4.26,42.99) 4.68,43.27 4.83,43.41 arc(5.37,43.78) C28.1
ADC_CLKM: length 3.1
  TOP w0.229: U1.28 22.07,42.49 22.01,42.55 20.59,42.55 R26.1
  TOP w0.305: C430.2 20.33,42.29 R26.1
ADC_CLKP: length 3.1
  TOP w0.229: U1.27 22.07,42.99 22.01,42.93 20.49,42.93 R26.2
  TOP w0.305: R26.2 20.36,43.05 C429.2
ADC_SCLK: length 45.1
  TOP w0.127: v1(30.27,50.79) 30.27,50.3 30.17,50.2 30.17,50.01 30.16,50 30.16,48.97 30.14,48.94 30.14,48.65 29.44,47.96 29.44,47.69 U1.6
  L4_SIG w0.127: v1(39.78,24.36) 39.78,24.51 37.54,26.75 37.54,28.7 35.41,30.84 35.41,31.17 34.06,32.51 33.25,32.51 31.86,33.91 27.28,33.91 26.05,35.14 26.05,38.36 25.82,38.59 25.82,39.11 26.33,39.61 26.53,39.61 26.98,40.07 26.98,47.78 26.48,48.28 26.48,49.95 26.89,50.36 29.12,50.36 29.56,50.79 v1(30.27,50.79)
  BOTTOM w0.127: v1(39.78,24.36) 39.8,24.33 U29.2
ADC_SDIO: length 39.6
  TOP w0.127: U1.5 29.89,47.92 30.39,48.43 30.39,48.84 30.42,48.86 30.42,49.9 30.42,49.9 30.42,50.09 v1(31.35,51.02)
  L4_SIG w0.127: v1(43.21,25.35) 43.21,26.06 40.64,28.63 39.57,28.63 35.53,32.66 35.53,33.35 30.66,38.23 30.12,38.23 29.77,38.58 29.77,47.19 30.33,47.75 30.33,50 v1(31.35,51.02)
  BOTTOM w0.127: v1(43.21,25.35) 43.21,24.08 42.81,23.68 U29.3
ADC_SDO: length 43.5
  TOP w0.127: v1(26.92,48.46) 26.89,48.42 U1.11
  L4_SIG w0.127: v1(33.07,48.13) 32.81,48.13 32.8,48.15 32.17,48.15 31.04,47.02 31.04,38.48 33.53,35.99 34.04,35.99 39.57,30.45 40.03,30.45 43.71,26.77 43.71,25.12 42.11,23.52 v1(40.39,23.52)
  BOTTOM w0.127: v1(40.39,23.52) 40.88,23.03 U29.4 ; v1(33.07,48.13) 32.81,48.13 32.8,48.15 32.02,48.15 31.48,47.61 27.7,47.61 26.92,48.39 v1(26.92,48.46)
ADC_SEN: length 39.4
  TOP w0.127: U1.7 28.89,47.86 29.71,48.68 v1(29.73,49.15)
  L4_SIG w0.127: v1(29.73,49.15) 29.47,48.89 29.47,48.21 28.37,47.12 28.37,38.58 29.01,37.95 29.87,37.95 30.07,37.74 30.53,37.74 32.35,35.93 32.35,34.84 35.9,31.29 35.9,30.88 36.58,30.2 37.53,30.2 38.46,29.27 38.46,28.53 38.05,28.12 38.05,26.71 40.22,24.54 40.22,24.17 39.96,23.91 39,23.91 v1(38.79,24.13)
  BOTTOM w0.127: U29.5 40.54,22.38 v1(38.79,24.13)
AIN+: length 4.1
  TOP w0.483: C1.1 T2.3 20.61,31.39 T1.1 18.83,29.65 R1.2
AIN-: length 4.1
  TOP w0.483: C6.1 T2.1 20.66,27.89 T1.3 R11.2
AINM: length 6
  TOP w0.635: C1.2 22.29,33.11 T2.4 23.4,34.23 arc(23.85,34.36) 24.21,34.06 arc(24.38,33.9) 24.6,33.82 arc(24.96,33.92) 25.15,34.23 arc(25.23,34.79) 25.26,35.35 25.26,36.39
AINP: length 5.9
  TOP w0.635: C6.2 24.1,31.33 T2.6 25.05,32.28 arc(25.85,33.48) 26.13,34.89 26.13,36.53
B_IN_M: length 14.7
  TOP w0.483: J4.1 4.15,53.05 arc(4.6,53.14) 4.98,53.39 11.56,59.97 arc(12.34,60.5) 13.27,60.68 13.69,60.68 C417.1
B_IN_P: length 14.7
  TOP w0.483: J3.1 4.39,63.21 arc(4.92,63.31) 5.37,63.61 5.67,63.92 arc(6.2,64.27) 6.81,64.39 13.5,64.39 arc(14.17,64.26) 14.74,63.88 C416.1
BIN+: length 4.1
  TOP w0.483: R23.2 18.3,56.35 T3.3 T4.1 C12.1
BIN-: length 3.3
  TOP w0.483: R13.2 T3.1 T4.3
BINM: length 5.9
  TOP w0.635: 25.45,49.2 25.45,50.92 arc(25.09,51.49) 24.42,51.42 24.07,51.07 23.59,51.07 T4.6
  TOP w0.762: C12.2 T4.6
BINP: length 6
  TOP w0.635: 26.34,49.05 26.34,51.01 arc(26.18,51.82) 25.71,52.52 24.65,53.58 T4.4
  TOP w0.762: C7.2 T4.4
CE: length 18.4
  L6_PWR w0.305: v1(48.67,63.7) 48.62,63.65 39.57,63.65 38.48,64.74 34.47,64.74 JP2.2
  BOTTOM w0.305: v1(48.67,63.7) 48.66,63.69 U30.1
CLK-IN: length 4.3
  BOTTOM w0.483: R57.2 R59.1 63.15,63.12 63.45,62.81 T6.6 R56.1
CLK_LAO_0M: length 39.8
  BOTTOM w0.165: 127.64,51.56 127.64,51.9 127.47,52.07 123.51,52.07 123.44,52.01
  BOTTOM w0.203: 90.47,52.66 90.44,52.69 R79.2
  BOTTOM w0.229: 123.44,52.01 118.35,52.01 116.48,50.14 114.52,50.14 112.69,51.97 91.16,51.97 90.47,52.66
CLK_LAO_0P: length 39.8
  BOTTOM w0.165: 123.44,52.39 123.51,52.32 127.47,52.32 127.64,52.49 127.64,52.83
  BOTTOM w0.203: R75.2 90.69,52.98 90.73,52.94
  BOTTOM w0.229: 90.73,52.94 91.32,52.35 91.93,52.35 92.29,52.7 92.76,52.7 93.12,52.35 112.85,52.35 114.68,50.52 116.33,50.52 118.19,52.39 123.44,52.39
CLKIN1_N: length 6.5
  BOTTOM w0.229: C74.2 72.79,64.64 72.8,64.66 72.86,64.66 72.89,64.69 73.58,64.69 C75.2 73.71,64.72 74.47,63.96 76.65,63.96 77.1,63.51 77.1,62.87 77.16,62.81 U3.35
CLKIN1_P: length 6.1
  BOTTOM w0.229: C73.2 72.77,64.08 72.96,64.27 73.62,64.27 74.31,63.58 76.49,63.58 76.72,63.35 76.72,62.87 76.66,62.81 U3.34
CLKINN: length 4.4
  BOTTOM w0.483: T6.3 69.8,65.35 R60.2 70.51,64.64 C74.1
CLKINP: length 5.4
  BOTTOM w0.483: C73.1 71.4,63.88 R55.1 70.43,63.8 R60.1 69.44,62.81 T6.1 R56.2
CLKLA_0M: length 6.3
  BOTTOM w0.203: 89.67,53.12 89.62,53.12 89.05,53.7
  BOTTOM w0.229: 89.05,53.7 89.08,53.73 89.08,54.07 88.85,54.31 88.42,54.31 88.08,53.98 87.73,53.98 87.4,54.31 86.1,54.31 85.95,54.16 85.43,54.16 85.37,54.1 U3.63
CLKLA_0P: length 6.3
  BOTTOM w0.203: R77.1 90.26,53.78 R75.1
  BOTTOM w0.229: U3.62 85.37,54.6 85.43,54.54 85.8,54.54 85.94,54.69 89.01,54.69 89.38,54.31 89.66,54.31 R77.1
CLKM: length 53.5
  TOP w0.229: v1(36.3,56.41) 36.3,58.18 34.75,59.73 33.93,59.73 33.71,59.5 v1(33.71,58.93)
  BOTTOM w0.229: C9.2 75.67,48.02 75.86,47.83 75.86,46.98 75.44,46.56 74.51,46.56 74.31,46.76 74.31,46.97 74.11,47.17 73.82,47.17 73.62,46.97 73.62,46.76 73.42,46.56 45.09,46.56 44.32,47.33 44.32,47.61 44.45,47.74 44.45,48.03 44.25,48.23 43.97,48.23 43.83,48.09 43.55,48.09 37.97,53.68 37.97,54.24 37.76,54.44 37.2,54.44 36.93,54.71 36.93,55.87 36.39,56.41 v1(36.3,56.41)
CLKP: length 53.5
  TOP w0.229: v1(33.73,60.91) 33.71,60.34 33.93,60.11 34.91,60.11 36.68,58.34 36.68,56.7 36.77,56.61 36.77,56.02 v1(36.42,55.68)
  BOTTOM w0.229: C8.2 76.43,48.02 76.24,47.83 76.24,46.82 75.6,46.18 44.93,46.18 36.55,54.55 36.55,55.55 v1(36.42,55.68)
CP1: length 37.8
  L4_SIG w0.305: v1(104.6,62.76) 104.34,62.76 102.84,64.26 96.6,64.26 95.61,65.25 94.39,65.25 93.8,64.67 82.91,64.67 80.98,62.74 78.49,62.74 77.57,63.65 74.76,63.65 74.22,63.11 74.22,61.62 73.71,61.11 v1(73.25,61.11)
  BOTTOM w0.305: v1(73.25,61.11) 73.26,61.11 U3.32
  vias: v1(105.36,62.76)
CP2: length 5.6
  BOTTOM w0.305: C71.1 87.35,62.41 C72.1 85.37,62.41 85.01,62.76 82.97,62.76 82.66,62.46 U3.46
CPOUT: length 15
  TOP w0.229: v1(47.14,57.35) 50.72,60.93 v1(50.72,66.32)
  BOTTOM w0.229: U30.12 45.16,57.64 45.44,57.35 v1(47.14,57.35) ; R182.1 49.15,66.37 C395.1 50.67,66.37 v1(50.72,66.32)
DA0_M: length 2.8
  TOP w0.229: C14.1 35.04,41.81 33.62,41.81 33.49,41.94 32.59,41.94 U1.62
DA0_P: length 2.8
  TOP w0.229: U1.61 32.6,41.55 33.33,41.55 33.46,41.43 34.99,41.43 C13.1
DA0M: length 106.8
  TOP w0.229: C14.2 36,41.78 40.28,41.78 43.66,38.4 121.43,38.4 124.66,41.63 126.31,41.63 130.88,46.2 134.52,46.2 135.23,45.5 135.23,44.83 134.78,44.37 134.29,44.37 133.99,44.07 v1(133.99,43.94)
DA0P: length 106.8
  TOP w0.229: C13.2 36,41.4 40.13,41.4 43.5,38.02 121.59,38.02 124.82,41.25 126.47,41.25 127.15,41.93 127.61,41.93 127.91,42.24 127.91,42.7 129.79,44.57 130.07,44.57 130.29,44.34 130.58,44.34 130.78,44.55 130.78,44.83 130.55,45.05 130.55,45.34 131.04,45.82 134.37,45.82 134.85,45.34 134.85,44.98 134.62,44.75 134.29,44.75 133.99,45.06 v1(133.99,45.21)
DA1_M: length 3.1
  TOP w0.229: U1.59 32.79,40.49 32.85,40.43 33.79,40.43 34.58,39.64 35.03,39.64 C16.1
DA1_P: length 3.1
  TOP w0.229: U1.58 32.77,39.99 32.83,40.05 33.63,40.05 34.42,39.26 35,39.26 C15.1
DA1M: length 108.3
  TOP w0.229: v1(135.25,41.4) 135.73,41.88 136.15,41.88 136.6,42.33 136.6,43.34 136.15,43.79 134.74,43.79 134.18,43.23 131.69,43.23 127.99,39.52 125.39,39.52 122.17,36.3 42.45,36.3 39.12,39.62 36,39.62 C16.2
DA1P: length 108.2
  TOP w0.229: v1(135.25,42.67) 135.67,42.26 135.99,42.26 136.22,42.49 136.22,43.18 135.99,43.41 134.9,43.41 134.34,42.85 131.85,42.85 131.57,42.57 131.57,42.28 131.67,42.19 131.67,41.9 131.47,41.7 131.18,41.7 131.09,41.8 130.8,41.8 129.18,40.18 129.18,39.9 129.29,39.79 129.29,39.5 129.09,39.3 128.81,39.3 128.7,39.41 128.41,39.41 128.14,39.14 125.55,39.14 122.33,35.92 42.29,35.92 38.96,39.24 36,39.24 C15.2
DA2_M: length 3.3
  TOP w0.229: U1.56 32.8,38.99 32.85,38.93 33.39,38.93 34.81,37.51 35.06,37.51 C18.1
DA2_P: length 3.4
  TOP w0.229: U1.55 32.72,38.49 32.78,38.55 33.23,38.55 34.67,37.11 34.99,37.11 C17.1
DA2M: length 106.4
  TOP w0.229: C18.2 36,37.47 38.21,37.47 41.36,34.32 122.78,34.32 125.75,37.29 128.06,37.29 132.2,41.43 134.27,41.43 135.15,40.55 135.15,39.77 134.69,39.32 134.28,39.32 133.99,39.02 v1(133.99,38.86)
DA2P: length 106.4
  TOP w0.229: v1(133.99,40.13) 133.99,39.93 134.21,39.7 134.54,39.7 134.77,39.93 134.77,40.39 134.11,41.05 132.36,41.05 131.75,40.44 131.75,40.16 131.99,39.92 131.99,39.64 131.79,39.43 131.5,39.43 131.27,39.67 130.98,39.67 128.22,36.91 127.45,36.91 127.14,36.6 126.76,36.6 126.45,36.91 125.91,36.91 122.94,33.93 41.2,33.93 38.05,37.08 36,37.08 C17.2
DA3_M: length 5.3
  TOP w0.229: U1.54 31.84,37.79 31.84,37.56 32.69,36.7 33.56,36.7 33.79,36.47 33.79,36.15 33.66,36.02 33.66,35.74 34.09,35.31 35.01,35.31 C20.1
DA3_P: length 5.3
  TOP w0.229: U1.53 31.46,37.77 31.46,37.4 33.93,34.92 35.01,34.92 C19.1
DA3M: length 107.2
  TOP w0.229: C20.2 36,35.31 37.11,35.31 40.24,32.18 130.72,32.18 131.08,32.54 131.41,32.54 131.76,32.18 133.43,32.18 135.28,34.04 135.28,34.32 135.07,34.53 135.07,34.82 135.27,35.02 135.56,35.02 135.77,34.81 136.05,34.81 136.4,35.15 136.4,36.54 136.17,36.77 135.7,36.77 v1(135.25,36.32)
DA3P: length 107.3
  TOP w0.229: C19.2 36,34.92 36.96,34.92 40.08,31.8 133.58,31.8 136.78,35 136.78,36.7 136.33,37.15 135.7,37.15 v1(135.25,37.59)
DB0_M: length 2.8
  TOP w0.229: U1.65 32.84,43.49 32.9,43.54 35.03,43.54 C22.1
DB0_P: length 2.8
  TOP w0.229: U1.66 32.85,43.99 32.91,43.93 35,43.93 C21.1
DB0M: length 103.9
  TOP w0.229: C22.2 36,43.56 41.02,43.56 44.45,40.13 120.73,40.13 123.98,43.38 126.03,43.38 129.59,46.94 134.8,46.94 v1(135.25,46.48)
DB0P: length 103.9
  TOP w0.229: C21.2 36,43.94 41.18,43.94 44.61,40.51 120.57,40.51 123.82,43.76 125.88,43.76 129.43,47.32 134.82,47.32 v1(135.25,47.75)
DB1_M: length 3.1
  TOP w0.229: C24.1 35.01,45.72 34.42,45.72 33.74,45.05 32.9,45.05 32.84,44.99 U1.68
DB1_P: length 3.1
  TOP w0.229: C23.1 35.01,46.1 34.26,46.1 33.59,45.43 32.88,45.43 32.82,45.49 U1.69
DB1M: length 102.8
  TOP w0.229: C24.2 36,45.72 41.94,45.72 45.49,42.16 119.86,42.16 129.72,52.02 132.33,52.02 132.72,51.64 v1(132.72,51.56)
DB1P: length 102.7
  TOP w0.229: v1(132.72,52.83) 132.72,52.78 132.33,52.4 129.56,52.4 119.7,42.55 45.65,42.55 42.09,46.1 36,46.1 C23.2
DB2_M: length 3.3
  TOP w0.229: C27.1 35.04,47.85 34.6,47.85 33.3,46.55 32.84,46.55 32.77,46.49 U1.71
DB2_P: length 3.3
  TOP w0.229: U1.72 32.77,46.99 32.82,46.94 33.14,46.94 34.44,48.23 34.99,48.23 C26.1
DB2M: length 106.2
  TOP w0.229: v1(135.25,51.56) 135.25,51.74 134.95,52.04 134.09,52.04 133.48,52.65 133.48,53.14 132.89,53.72 128.81,53.72 119.39,44.3 46.74,44.3 43.15,47.88 36,47.88 C27.2
DB2P: length 106.2
  TOP w0.229: C26.2 36,48.26 43.31,48.26 46.89,44.68 119.23,44.68 128.65,54.1 133.05,54.1 133.86,53.29 133.86,52.81 134.24,52.43 135.03,52.43 135.25,52.65 v1(135.25,52.83)
DB3_M: length 5.3
  TOP w0.229: C31.1 35.01,50.04 33.91,50.04 33.66,49.78 33.66,49.38 33.76,49.28 33.76,48.94 33.48,48.67 32.54,48.67 31.83,47.96 31.83,47.69 U1.1
DB3_P: length 5.3
  TOP w0.229: C30.1 35.01,50.42 33.75,50.42 31.45,48.11 31.45,47.7 U1.2
DB3M: length 106
  TOP w0.229: v1(135.25,56.64) 135.25,56.82 134.98,57.1 131.96,57.1 131.68,56.82 129.01,56.82 118.36,46.18 47.9,46.18 44.02,50.06 36.03,50.06 C31.2
DB3P: length 105.9
  TOP w0.229: C30.2 35.98,50.44 44.18,50.44 48.06,46.56 118.21,46.56 128.85,57.2 131.52,57.2 131.8,57.48 135.03,57.48 135.25,57.71 v1(135.25,57.91)
DCLKOUT10N: length 4.2
  BOTTOM w0.229: U3.55 84.9,58.11 84.96,58.17 87.15,58.17 R151.1 87.73,58.14 88.09,58.14 C171.1
DCLKOUT10P: length 4.1
  BOTTOM w0.229: C170.1 88.09,58.5 87.73,58.5 R152.1 87.2,58.52 84.99,58.52 84.9,58.61 U3.54
FMC_GPIO2: length 173.2
  L4_SIG w0.127: v1(18.57,52.04) 18.57,51.44 17.7,50.57 17.7,48.26 20.05,45.91 20.05,41.81 20.03,41.79 20.03,40.37 18.57,38.91 18.57,34.37 23.2,29.73 24.06,29.73 24.32,29.47 24.32,28.61 26.11,26.82 26.11,19.81 30.79,15.14 42.6,15.14 44.73,17.27 48.48,17.27 49.06,16.69 54.99,16.69 55.52,16.15 60.45,16.15 61.49,17.2 77.4,17.2 84.45,10.15 85.26,10.15 85.38,10.02 98.03,10.02 98.91,10.9 113.84,10.9 118.8,5.94 119.99,5.94 122.68,8.64 122.68,25.93 123.47,26.72 132.16,26.72 132.72,27.28 v1(132.72,27.43)
  BOTTOM w0.229: R165.1 v1(18.57,52.04)
FMC_GPIO3: length 172.3
  L4_SIG w0.127: v1(17.75,51.26) 17.3,50.8 17.3,48.11 19.72,45.68 19.72,40.68 18.14,39.09 18.14,34.11 25.65,26.59 25.65,19.56 30.58,14.63 42.9,14.63 45.14,16.87 47.93,16.87 49.15,15.65 60.65,15.65 61.67,16.66 69.75,16.66 70.17,16.24 70.73,16.24 71.15,15.82 78.18,15.82 84.21,9.79 84.54,9.79 85.3,9.03 99.63,9.03 100.96,10.36 113.56,10.36 118.44,5.49 120.29,5.49 123.24,8.43 123.24,25.2 123.47,25.43 131.98,25.43 v1(132.72,26.16)
  BOTTOM w0.229: 18.16,50.83 v1(17.75,51.26)
FPGA_JESD_CLKM: length 55.2
  BOTTOM w0.165: 123.44,50.75 123.5,50.81 129.22,50.81 129.66,51.25 129.66,54.32 129.95,54.61 131.28,54.61 131.44,54.44 J10.D5
  BOTTOM w0.229: 123.44,50.75 122.97,50.75 118.39,46.18 84.89,46.18 83.49,47.57 83.49,48.25 C69.2
FPGA_JESD_CLKP: length 55.2
  BOTTOM w0.165: J10.D4 131.44,55.03 131.28,54.86 129.84,54.86 129.41,54.43 129.41,51.35 129.11,51.06 123.53,51.06 123.46,51.13 123.44,51.13
  BOTTOM w0.229: 123.44,51.13 122.81,51.13 121.92,50.25 121.62,50.25 121.26,49.89 121.26,49.58 118.24,46.56 86.85,46.56 86.65,46.76 86.65,46.81 86.45,47.02 86.16,47.02 85.96,46.81 85.96,46.76 85.76,46.56 85.04,46.56 83.87,47.73 83.87,48.26 C67.2
FPGA_JESD_SYSREFM: length 50.6
  BOTTOM w0.165: 123.44,48.2 123.46,48.2 123.53,48.26 127.47,48.26 127.64,48.09 127.64,47.75
  BOTTOM w0.203: 123.25,48.2 119.35,44.3 83.39,44.3 81.21,46.47 81.21,47.46 R49.2
  BOTTOM w0.229: 123.44,48.2 123.25,48.2
FPGA_JESD_SYSREFP: length 50.6
  BOTTOM w0.165: 123.44,48.58 123.46,48.58 123.53,48.52 127.13,48.52 127.64,49.02
  BOTTOM w0.203: R48.2 81.57,47.46 81.57,46.62 81.91,46.27 82.17,46.27 82.27,46.38 82.52,46.38 82.7,46.2 82.7,45.95 82.6,45.84 82.6,45.59 83.54,44.65 117.99,44.65 118.19,44.86 118.65,44.86 118.85,44.65 119.21,44.65 122.89,48.33 122.89,48.35 123.1,48.57 123.2,48.57 123.22,48.58 123.25,48.58
  BOTTOM w0.229: 123.44,48.58 123.25,48.58
GPIO1: length 46.6
  TOP w0.127: U1.19 22.74,48.05 v1(22.43,48.36)
  L4_SIG w0.127: v1(22.43,48.36) 22.43,49.53 24.46,51.56 32.76,51.56 36.09,48.23 36.09,46.3 46.82,35.57 47.22,35.57 49.02,33.78 49.02,32.87 50.57,31.32 50.57,30.05 52.7,27.91 TP3.1
GPIO2: length 59.1
  TOP w0.229: U1.20 22.48,46.49 19.69,49.27 v1(19.69,50.92)
  L4_SIG w0.127: v1(19.69,50.92) 19.69,50.34 19.96,50.06 21.44,50.06 23.93,52.55 34.6,52.55 37.9,49.25 37.9,46.97 38.82,46.05 39.17,46.05 48.82,36.4 49.42,36.4 52.93,32.89 52.93,31.9 57.53,27.3 TP7.1
  BOTTOM w0.229: v1(19.69,50.92) 19.69,50.5 R40.2
GPIO3: length 66.4
  TOP w0.229: U1.21 22.11,45.99 18.88,49.22 v1(18.88,50.11)
  L4_SIG w0.127: TP32.1 61.57,26.01 56.44,26.01 51.46,30.99 51.46,32.44 48.95,34.95 48.95,35.5 39.17,45.28 38.7,45.28 37.41,46.56 37.41,49.2 34.49,52.12 24.16,52.12 21.64,49.61 19.84,49.61 19.33,50.11 v1(18.88,50.11)
  BOTTOM w0.229: R40.1 19.22,50.11 v1(18.88,50.11)
GPIO4: length 43.3
  TOP w0.127: U1.63 v1(33.69,42.49)
  L4_SIG w0.127: TP33.1 66.07,25.43 53.03,25.43 46.41,32.05 46.03,32.05 35.92,42.16 34.01,42.16 v1(33.69,42.49)
GTXCLKM: length 4.1
  BOTTOM w0.203: U3.2 83.16,51.94 83.24,51.87 83.24,51.33 83.5,51.07 83.5,50.12 83.27,49.9 ; 83.3,49.82 R52.1 ; C69.1 83.3,49.11
  BOTTOM w0.229: 83.27,49.9 83.3,49.87 83.3,49.11
GTXCLKP: length 4.1
  BOTTOM w0.203: U3.1 83.66,51.94 83.59,51.87 83.59,51.48 83.86,51.22 83.86,50.12 84.08,49.9 ; C67.1 84.06,49.11 ; 84.06,49.82 R53.1
  BOTTOM w0.229: 84.06,49.11 84.06,49.87 84.08,49.9
JESD_SYSREFM: length 5.2
  BOTTOM w0.203: 81.01,49.03 R50.1 ; R49.1 81.01,48.32 ; U3.4 82.16,51.94 82.24,51.87 82.24,51.58 81.23,50.58 81.23,49.35 80.99,49.11
  BOTTOM w0.229: 81.01,48.32 81.01,49.08 80.99,49.11
JESD_SYSREFP: length 5.2
  BOTTOM w0.203: R48.1 81.77,48.32 ; 81.8,49.11 81.58,49.32 81.58,50.43 82.59,51.43 82.59,51.87 82.66,51.94 U3.3 ; 81.77,49.03 R51.1
  BOTTOM w0.229: 81.77,48.32 81.77,49.08 81.8,49.11
LMK LOCKED:
  vias: v1(55.78,55.65)
LMK_CLKIN: length 4.6
  BOTTOM w0.483: J7.1 55.83,63.12 R58.1 R57.1
LMK_CSB: length 77.8
  L4_SIG w0.127: v1(32.73,19.47) 34.9,19.47 35.31,19.88 44.13,19.88 44.51,19.49 46.44,19.49 47.14,20.19 71.65,20.19 73.61,22.15 73.61,46.51 74.42,47.32 74.42,50.29 v1(73.91,50.8)
  BOTTOM w0.127: U3.18 73.92,54.1 73.6,53.78 73.6,51.12 v1(73.91,50.8) ; U5.6 v1(32.73,19.47)
LMK_SCLK: length 111.5
  TOP w0.127: v1(37.31,25.37) 37.31,24.92 36.7,24.31 34.37,24.31 v1(32.78,22.72)
  L4_SIG w0.127: v1(37.31,25.37) 37.31,23.6 39.24,21.67 45.9,21.67 46.2,21.36 50.39,21.36 52.7,23.67 67.36,23.67 71.49,27.8 71.49,49.72 72.03,50.27 v1(72.03,50.8) 54.84,50.8 52.32,53.32 50.45,53.32 50.22,53.09 49.12,53.09 48.49,53.72 47.09,53.72 46.38,54.43 46.38,54.69 44.81,56.26 43.76,56.26 43.13,56.9 v1(43.13,57.23)
  BOTTOM w0.127: U30.16 43.16,57.26 v1(43.13,57.23) ; v1(37.31,25.37) 37.31,24.87 36.78,24.33 U29.13 ; v1(72.03,50.8) 72.11,50.88 72.67,50.88 73.23,51.44 73.23,53.77 74.06,54.6 U3.19 ; U5.1 v1(32.78,22.72)
LMK_SDIO: length 116.5
  L4_SIG w0.127: v1(42.65,57.63) 42.65,58.47 43.48,59.31 44.86,59.31 45.14,59.03 45.14,57.78 46.37,56.55 46.37,55.66 46.98,55.05 47.15,55.05 47.43,54.77 47.43,54.55 47.82,54.17 49.59,54.17 49.83,53.92 52.32,53.92 54.89,51.36 v1(72.47,51.36) 72.54,51.28 72.54,49.96 72.03,49.45 72.03,37.95 72.47,37.52 72.47,35.94 72.09,35.56 72.09,27.53 67.61,23.06 52.93,23.06 50.67,20.8 46.09,20.8 45.78,21.12 42.81,21.12 42.24,20.55 40.56,20.55 40.31,20.8 35.38,20.8 34.7,20.12 v1(33.5,20.12) 33.5,22.99 34.2,23.68 v1(34.84,23.68)
  BOTTOM w0.127: U3.20 73.95,55.1 72.92,54.08 72.92,51.82 v1(72.47,51.36) ; U30.17 v1(42.65,57.63) ; U29.12 v1(34.84,23.68) ; U5.5 v1(33.5,20.12)
LMK_SDO: length 82.7
  TOP w0.127: v2(81.66,52.78) 81.66,52.45 80.29,51.08 75.29,51.08 v1(74.94,50.74)
  L4_SIG w0.127: v1(33.38,16.87) 35.89,19.38 41.61,19.38 41.73,19.49 43.73,19.49 44.2,19.02 46.89,19.02 47.35,19.48 71.75,19.48 75.68,23.41 75.68,43.62 75.67,43.63 75.67,50.01 v1(74.94,50.74)
  BOTTOM w0.127: U5.10 v1(33.38,16.87)
LMX_CLKB: length 23.4
  BOTTOM w0.483: C412.2 43.38,54.38 R192.2 47.21,53.75 arc(48.13,53.93) 48.92,54.45 51.78,57.32 arc(52.47,57.78) 53.27,57.94 59.59,57.94 arc(60.43,58.1) 61.14,58.58 arc(61.4,58.97) 61.49,59.44 61.49,62.1
LMX_CLKM: length 30.1
  TOP w0.229: U32.3 17.68,44.98 v1(17.02,44.98)
  BOTTOM w0.229: v1(17.02,44.98) 17.02,44.07 16.79,43.84 16.21,43.84 15.44,44.6 15.44,44.88 15.59,45.02 15.59,45.35 15.44,45.49 15.44,45.75 15.72,46.02 15.88,46.02 16.21,45.68 16.37,45.68 16.5,45.81 16.5,46.14 16.33,46.31 16.33,46.63 16.74,47.04 19.2,47.04 31.14,58.98 31.42,58.98 31.69,59.25 31.69,59.52 31.89,59.73 33.12,59.73 33.32,59.54 C410.2
LMX_CLKP: length 30.1
  TOP w0.229: v1(17.02,42.32) 17.68,42.32 U33.3
  BOTTOM w0.229: C409.2 33.32,60.3 33.12,60.11 31.73,60.11 19.04,47.42 16.58,47.42 15.06,45.9 15.06,44.44 16.05,43.46 16.79,43.46 17.02,43.23 v1(17.02,42.32)
LMX_CSB: length 72.6
  L4_SIG w0.127: v1(30.05,17.53) 29.87,17.7 29.87,19.63 30.52,20.29 30.52,22.51 29.11,23.93 29.11,26.54 27.3,28.35 27.3,29.87 25.5,31.67 25.5,39.22 25.7,39.42 25.7,45.52 25.1,46.13 20.94,46.13 18.41,48.65 18.41,50.27 18.43,50.28 18.43,50.29 18.69,50.56 18.7,50.56 19.24,51.1 19.24,51.11 19.5,51.37 19.64,51.37 21.58,53.31 25.15,53.31 26.5,54.67 32.3,54.67 32.49,54.48 36.65,54.48 37.17,55 37.17,55.3 37.43,55.56 38.04,55.56 38.61,56.13 38.61,56.58 37.9,57.3 37.9,57.99 39.32,59.41 v1(39.32,61.32)
  BOTTOM w0.127: U5.9 v1(30.05,17.53) ; U30.24 39.71,60.69 39.32,61.09 v1(39.32,61.32)
LMX_OSCM: length 39.9
  TOP w0.229: v1(50,57.45) 50.25,57.71 64.57,57.71 72.95,66.09 74.85,66.09 v1(75.08,65.86)
  BOTTOM w0.203: C418.2 79.72,65.8 79.72,66.5 79.44,66.78 79.08,66.78 78.9,66.6 78.9,66.45 78.73,66.27 78.47,66.27 78.29,66.45 78.29,66.6 78.12,66.78 76.4,66.78 75.79,66.17 75.39,66.17 v1(75.08,65.86)
  BOTTOM w0.229: v1(50,57.45) 49.71,57.74 49.21,57.74 47.22,59.74 46.48,59.74 U30.9
LMX_OSCP: length 39.9
  TOP w0.229: v1(50,58.37) 50.28,58.09 64.41,58.09 72.79,66.47 74.77,66.47 v1(75.08,66.78)
  BOTTOM w0.203: v1(75.08,66.78) 75.34,66.52 75.64,66.52 76.25,67.13 79.59,67.13 80.07,66.64 80.07,65.8 C419.2
  BOTTOM w0.229: v1(50,58.37) 49.76,58.14 49.36,58.14 47.37,60.12 46.51,60.12 U30.8
LMX_SDO: length 62.1
  L4_SIG w0.127: v1(30.08,22.07) 28.65,23.5 28.65,25.58 25.7,28.52 25.7,29.51 22.76,32.46 22.76,38.71 23.66,39.61 23.9,39.61 24.51,40.22 24.51,44.36 24,44.87 23.42,44.87 22.72,45.57 20.88,45.57 18.11,48.34 18.11,50.42 19.2,51.51 19.2,52.73 22.61,56.13 28.75,56.13 29.74,55.14 32.49,55.14 32.74,54.89 36.5,54.89 36.87,55.26 36.87,55.64 37.59,56.36 v1(38.07,56.36)
  BOTTOM w0.127: U5.2 v1(30.08,22.07)
Net_60:
  vias: v3(126.36,21.08)
Net_97:
  vias: v3(123.83,24.89)
Net_98:
  vias: v3(123.83,23.62)
Net_99:
  vias: v3(123.83,13.46)
Net_100:
  vias: v3(123.83,12.19)
Net_102:
  vias: v1(126.36,40.13)
Net_103:
  vias: v1(127.64,40.13)
Net_216:
  vias: v3(135.25,31.24)
Net_217:
  vias: v3(135.25,27.43)
Net_218:
  vias: v3(135.25,26.16)
Net_219:
  vias: v3(135.25,22.35)
Net_220:
  vias: v3(135.25,21.08)
Net_221:
  vias: v3(135.25,17.27)
Net_222:
  vias: v3(135.25,16)
Net_223:
  vias: v3(135.25,12.19)
Net_224:
  vias: v3(135.25,10.92)
Net_225:
  vias: v3(133.99,59.18)
Net_226:
  vias: v3(133.99,35.05)
Net_227:
  vias: v3(133.99,33.78)
Net_228:
  vias: v3(133.99,29.97)
Net_229:
  vias: v3(133.99,28.7)
Net_230:
  vias: v3(133.99,24.89)
Net_231:
  vias: v3(133.99,23.62)
Net_232:
  vias: v3(133.99,19.81)
Net_233:
  vias: v3(133.99,18.54)
Net_234:
  vias: v3(133.99,14.73)
Net_235:
  vias: v3(133.99,13.46)
Net_236:
  vias: v3(133.99,55.37)
Net_237:
  vias: v3(133.99,9.65)
Net_238:
  vias: v3(133.99,54.1)
Net_239:
  vias: v3(133.99,50.29)
Net_240:
  vias: v3(133.99,49.02)
Net_243:
  vias: v3(132.72,36.32)
Net_246:
  vias: v3(132.72,31.24)
Net_248:
  vias: v3(132.72,22.35)
Net_249:
  vias: v3(132.72,21.08)
Net_250:
  vias: v3(132.72,17.27)
Net_251:
  vias: v3(132.72,16)
Net_252:
  vias: v3(132.72,13.46)
Net_253:
  vias: v3(132.72,10.92)
Net_254:
  vias: v3(131.44,59.18)
Net_256:
  vias: v3(131.44,45.21)
Net_259:
  vias: v3(131.44,35.05)
Net_260:
  vias: v3(131.44,33.78)
Net_261:
  vias: v3(131.44,31.24)
Net_262:
  vias: v3(131.44,29.97)
Net_263:
  vias: v3(131.44,27.43)
Net_264:
  vias: v3(131.44,26.16)
Net_265:
  vias: v3(131.44,23.62)
Net_266:
  vias: v3(131.44,22.35)
Net_267:
  vias: v3(131.44,21.08)
Net_268:
  vias: v3(131.44,19.81)
Net_269:
  vias: v3(131.44,18.54)
Net_270:
  vias: v3(131.44,17.27)
Net_271:
  vias: v3(131.44,16)
Net_272:
  vias: v3(131.44,14.73)
Net_273:
  vias: v3(131.44,12.19)
Net_274:
  vias: v3(131.44,9.65)
Net_275:
  vias: v3(131.44,50.29)
Net_276:
  vias: v3(131.44,49.02)
Net_282:
  vias: v3(130.18,37.59)
Net_285:
  vias: v3(130.18,33.78)
Net_287:
  vias: v3(130.18,29.97)
Net_288:
  vias: v3(130.18,28.7)
Net_289:
  vias: v3(130.18,26.16)
Net_290:
  vias: v3(130.18,24.89)
Net_292:
  vias: v3(130.18,22.35)
Net_293:
  vias: v3(130.18,21.08)
Net_294:
  vias: v3(130.18,18.54)
Net_295:
  vias: v3(130.18,17.27)
Net_296:
  vias: v3(130.18,14.73)
Net_297:
  vias: v3(130.18,13.46)
Net_298:
  vias: v3(130.18,10.92)
Net_301:
  vias: v3(130.18,49.02)
Net_302:
  vias: v3(128.91,59.18)
Net_303:
  vias: v3(128.91,47.75)
Net_306:
  vias: v3(128.91,42.67)
Net_309:
  vias: v3(128.91,36.32)
Net_312:
  vias: v3(128.91,31.24)
Net_313:
  vias: v3(128.91,28.7)
Net_314:
  vias: v3(128.91,27.43)
Net_315:
  vias: v3(128.91,24.89)
Net_316:
  vias: v3(128.91,23.62)
Net_317:
  vias: v3(128.91,21.08)
Net_318:
  vias: v3(128.91,19.81)
Net_319:
  vias: v3(128.91,17.27)
Net_320:
  vias: v3(128.91,16)
Net_321:
  vias: v3(128.91,13.46)
Net_322:
  vias: v3(128.91,12.19)
Net_323:
  vias: v3(128.91,55.37)
Net_324:
  vias: v3(128.91,9.65)
Net_327:
  vias: v3(128.91,50.29)
Net_330:
  vias: v3(127.64,57.91)
Net_333:
  vias: v3(127.64,29.97)
Net_334:
  vias: v3(127.64,28.7)
Net_335:
  vias: v3(127.64,26.16)
Net_336:
  vias: v3(127.64,24.89)
Net_338:
  vias: v3(127.64,22.35)
Net_339:
  vias: v3(127.64,21.08)
Net_340:
  vias: v3(127.64,18.54)
Net_341:
  vias: v3(127.64,17.27)
Net_342:
  vias: v3(127.64,14.73)
Net_343:
  vias: v3(127.64,13.46)
Net_344:
  vias: v3(127.64,10.92)
Net_345:
  vias: v3(126.36,59.18)
Net_346:
  vias: v3(126.36,47.75)
Net_347:
  vias: v3(126.36,46.48)
Net_351:
  vias: v3(126.36,35.05)
Net_353:
  vias: v3(126.36,31.24)
Net_354:
  vias: v3(126.36,28.7)
Net_355:
  vias: v3(126.36,27.43)
Net_356:
  vias: v3(126.36,24.89)
Net_357:
  vias: v3(126.36,23.62)
Net_358:
  vias: v3(126.36,19.81)
Net_359:
  vias: v3(126.36,17.27)
Net_360:
  vias: v3(126.36,16)
Net_361:
  vias: v3(126.36,13.46)
Net_362:
  vias: v3(126.36,12.19)
Net_364:
  vias: v3(126.36,9.65)
Net_367:
  vias: v3(126.36,50.29)
Net_369:
  vias: v3(125.09,45.21)
Net_375:
  vias: v3(125.09,57.91)
Net_376:
  vias: v3(125.09,33.78)
Net_378:
  vias: v3(125.09,29.97)
Net_379:
  vias: v3(125.09,28.7)
Net_380:
  vias: v3(125.09,26.16)
Net_381:
  vias: v3(125.09,24.89)
Net_382:
  vias: v3(125.09,56.64)
Net_383:
  vias: v3(125.09,22.35)
Net_384:
  vias: v3(125.09,21.08)
Net_385:
  vias: v3(125.09,18.54)
Net_386:
  vias: v3(125.09,17.27)
Net_387:
  vias: v3(125.09,14.73)
Net_388:
  vias: v3(125.09,13.46)
Net_389:
  vias: v3(125.09,10.92)
Net_391:
  vias: v3(125.09,51.56)
Net_392:
  vias: v3(125.09,49.02)
Net_393:
  vias: v3(123.83,59.18)
Net_394:
  vias: v3(123.83,47.75)
Net_404:
  vias: v3(123.83,28.7)
Net_405:
  vias: v3(123.83,27.43)
Net_406:
  vias: v3(123.83,21.08)
Net_407:
  vias: v3(123.83,19.81)
Net_408:
  vias: v3(123.83,17.27)
Net_409:
  vias: v3(123.83,16)
Net_410:
  vias: v3(123.83,55.37)
Net_411:
  vias: v3(123.83,9.65)
Net_412:
  vias: v3(123.83,54.1)
Net_414:
  vias: v3(123.83,50.29)
OSCINN: length 7.3
  BOTTOM w0.229: C86.2 85.56,64.09 84.18,64.09 83.98,63.89 83.98,63.74 83.78,63.54 83.49,63.54 83.29,63.74 83.29,63.89 83.09,64.09 82.71,64.09 81.65,63.03 81.65,62.82 81.66,62.81 U3.44
  BOTTOM w0.305: C86.2 86.6,63.83 C85.2
OSCINP: length 7.4
  BOTTOM w0.229: U3.43 81.16,62.81 81.27,62.92 81.27,63.19 82.55,64.47 85.56,64.47 C83.2
  BOTTOM w0.305: C82.2 86.63,64.74 C83.2
OSCN: length 2.6
  BOTTOM w0.305: C84.2 89.71,63.83 R76.2 R82.1 87.36,63.83 C85.1
OSCOUTN: length 3.2
  BOTTOM w0.203: U3.41 80.16,62.77 80.09,62.84 80.09,64.26 80.24,64.41 ; 80.24,64.41 R180.1 ; 80.24,64.41 80.24,65.02 C419.1
OSCOUTP: length 3.3
  BOTTOM w0.203: 79.55,64.41 79.73,64.23 79.73,62.84 79.66,62.77 U3.40 ; 79.55,64.41 79.55,65.02 C418.1 ; 79.55,64.41 R181.1
OSCP: length 2.6
  BOTTOM w0.305: C81.2 89.72,64.76 R71.2 R74.1 87.36,64.76 C82.1
PDN: length 112.3
  TOP w0.127: U1.50 29.89,37.51 29.97,37.43 29.97,37.13 30.15,36.96 30.15,36.75 30.16,36.75 30.16,28.29 v1(30.18,28.27)
  L4_SIG w0.127: v1(30.18,28.27) 30.18,24.36 31.55,22.99 31.55,20.02 32.59,18.97 32.59,16.92 33.15,16.36 33.55,16.36 35.61,18.41 47.02,18.41 47.47,18.87 54.84,18.87 55.32,18.39 78.54,18.39 84.99,11.94 90.02,11.94 90.75,12.67 91.85,12.67 92.41,12.12 111.91,12.12 112.37,12.57 115.19,12.57 117.09,14.48 JP1.2
PG: length 45.9
  TOP w0.305: U18.2 83.08,6.2 v1(82.83,5.94)
  L4_SIG w0.127: v1(82.83,5.94) 80.89,7.89 73.6,7.89 68.15,13.34 v1(68.15,13.54) 67.08,14.61 54.97,14.61 54.31,15.26 47.48,15.26 v1(46.79,15.95)
  L6_PWR w0.305: v1(82.83,5.94) 83.44,6.55 85.62,6.55 v1(85.75,6.43)
  BOTTOM w0.127: U17.9 68.37,13.76 v1(68.15,13.54)
PLL2 LOCKED:
  vias: v1(58.62,55.68)
RESET: length 118.4
  TOP w0.127: U1.48 28.89,37.49 29.15,37.22 v1(29.16,27.56)
  L4_SIG w0.127: v1(29.16,27.56) 29.59,27.13 29.59,24.16 31.01,22.73 31.01,19.99 30.26,19.24 30.26,18.07 32.64,15.7 34.34,15.7 36.38,17.73 56.79,17.73 57.25,17.27 58.65,17.27 59.11,17.73 78.43,17.73 84.73,11.43 90.02,11.43 90.72,10.73 91.91,10.73 92.61,11.43 112.04,11.43 112.6,11.99 114.48,11.99 v1(119.86,6.6)
RFOUTBM: length 6.3
  TOP w0.483: J16.1 v1(40.94,53.72)
  BOTTOM w0.305: C413.2 40.34,54.33 v1(40.94,53.72)
STAT 0:
  vias: v1(61.47,55.7)
STAT 1:
  vias: v1(64.36,55.68)
SYNC: length 13.8
  TOP w0.229: TP25.1 69.32,52.55 75.97,52.55 76.99,51.54 79.92,51.54 v2(81.16,52.78)
SYNCBM: length 134.4
  TOP w0.229: v1(17.28,37.32) 17.51,37.55 19.04,37.55 R166.2 R168.1 20.33,37.55 21.4,37.55 22.33,38.49 U1.36
  BOTTOM w0.102: 123.44,46.07 123.59,46.07 123.67,45.99 127.94,45.99 128.36,45.57 128.36,44.7 128.15,44.48 127.74,44.48 127.64,44.38 127.64,43.94
  BOTTOM w0.203: v1(17.28,37.32) 16.99,37.62 16.31,37.62 15.82,37.13 15.82,36.63 16.08,36.37 16.2,36.37 16.38,36.19 16.38,35.94 16.2,35.76 16,35.76 15.82,35.58 15.82,34.47 19.94,30.35 66.45,30.35 78.64,42.55 119.77,42.55 123.3,46.07 123.44,46.07
SYNCBP: length 134.4
  TOP w0.229: v1(17.28,38.27) 17.61,37.93 19.04,37.93 R167.2 R169.1 20.33,37.93 21.24,37.93 22.29,38.99 U1.35
  BOTTOM w0.102: 127.64,45.21 127.64,44.77 127.74,44.67 128.07,44.67 128.17,44.77 128.17,45.49 127.86,45.8 123.53,45.8 123.44,45.71
  BOTTOM w0.203: v1(17.28,38.27) 16.99,37.97 16.16,37.97 15.47,37.28 15.47,34.32 19.79,30 66.59,30 78.79,42.19 119.92,42.19 123.44,45.71
SYSREF+: length 5.1
  BOTTOM w0.203: 78.75,49.11 78.55,49.31 78.55,50.62 77.59,51.58 77.59,51.87 77.66,51.94 U3.13 ; R65.1 78.73,48.32 ; 78.73,49.03 R67.1
  BOTTOM w0.229: 78.75,49.11 78.73,49.08 78.73,48.32
SYSREF-: length 5.2
  BOTTOM w0.203: R66.1 77.96,48.32 ; 77.96,49.03 R68.1 ; U3.14 77.16,51.94 77.23,51.87 77.23,51.43 78.2,50.47 78.2,49.37 77.94,49.11
  BOTTOM w0.229: 77.94,49.11 77.96,49.08 77.96,48.32
SYSREFM: length 80.3
  TOP w0.229: U1.34 22.47,39.49 22.43,39.52 22.13,39.52 21.85,39.25 21.36,39.25 v1(21.2,39.09)
  BOTTOM w0.203: 78,46.69 R69.1 77.91,46.85 77.93,46.85 ; 78,46.69 78.05,46.69 78.05,46.63 78.11,46.63 78.11,46.58 78.16,46.58 78.16,45.24 77.34,44.42 77.05,44.42 77.01,44.47 76.73,44.47 76.52,44.27 76.52,43.98 76.57,43.94 76.57,43.66 66.49,33.58 65.91,33.58 65.7,33.37 65.7,32.79 65.09,32.18 23.55,32.18 23.19,32.54 22.37,32.54 22.02,32.18 20.96,32.18 19.65,33.49 19.65,34.04 19.43,34.26 18.88,34.26 18.57,34.57 18.57,37.15 18.77,37.35 18.98,37.35 19.18,37.56 19.18,37.84 18.98,38.04 18.77,38.04 18.57,38.24 18.57,39.09 19,39.52 20.28,39.52 20.56,39.24 21.04,39.24 v1(21.2,39.09) ; 78,46.69 78,46.74 77.93,46.81 ; R66.2 77.96,47.61
  BOTTOM w0.229: 77.93,46.81 77.93,46.85 77.96,46.85 77.96,47.61
SYSREFP: length 80.3
  TOP w0.229: v1(21.2,39.8) 21.37,39.63 21.69,39.63 21.97,39.9 22.4,39.9 22.48,39.99 U1.33
  BOTTOM w0.203: 78.54,46.58 78.54,45.12 65.24,31.83 23.39,31.83 23.22,32 22.38,32 22.17,31.8 20.8,31.8 18.19,34.42 18.19,39.25 18.84,39.9 20.3,39.9 20.31,39.89 20.41,39.89 20.7,39.6 21,39.6 v1(21.2,39.8) ; 78.54,46.58 78.59,46.58 R70.1 78.78,46.85 78.77,46.85 ; 78.54,46.58 78.77,46.81 ; R65.2 78.73,47.61
  BOTTOM w0.229: 78.73,47.61 78.73,46.85 78.77,46.85 78.77,46.81
VCM: length 9.1
  TOP w0.254: 20.38,45.49 U1.22
  TOP w0.305: TP2.1 16.89,49.07 C61.1 18.29,47.57 20.38,45.49
Y2_N: length 13.9
  BOTTOM w0.229: R81.1 93.04,64.11 93.8,64.11 94.39,63.52 94.39,58.82 95.21,58 95.95,58 96.35,57.6 96.35,57.15 96.57,56.92 Y1.4
  BOTTOM w0.305: R81.1 92,63.83 R80.1
Y2_P: length 13.8
  BOTTOM w0.229: R73.1 93.04,64.49 93.95,64.49 94.77,63.68 94.77,58.98 95.36,58.38 95.92,58.38 96.35,58.8 96.35,59.23 96.57,59.46 Y1.5
  BOTTOM w0.305: R73.1 92,64.77 R72.1
YO2_N: length 0.9
  BOTTOM w0.305: C84.1 R80.2
YO2_P: length 0.9
  BOTTOM w0.305: C81.1 R72.2
N851442: length 3.9
  TOP w0.483: R1.1 16.62,27.44 T1.6 15.84,26.62 15.45,26.62 C424.2 15.14,26.27 C414.2
N16260551: length 3.8
  TOP w0.483: 16.54,62.07 16.54,62.07 C426.2 17.58,61.03 17.58,60.67 T3.6 R13.1
N17912008: length 3.8
  TOP w0.483: 16.54,23.35 17.32,24.13 C425.2 17.58,24.39 17.58,24.77 T1.4 R11.1
N18340257: length 5.2
  BOTTOM w0.305: R133.2 42.44,9.75 43.05,9.14 43.05,7.37 41.91,6.22 v1(41.27,6.22)
N19112270: length 3.7
  TOP w0.483: R23.1 16.66,58.03 T3.4 15.78,58.88 15.49,58.88 15.21,59.16 ; 15.21,59.16 14.46,59.92 ; 15.21,59.16 C427.2
N19631466: length 1.6
  TOP w0.305: C166.1 108.14,5.98 v1(108.14,5.15)
  BOTTOM w0.305: U12.14 v1(108.14,5.15)
N19631491: length 1.7
  TOP w0.305: R127.2 111.15,8.33 v1(111.99,8.33)
  BOTTOM w0.305: U12.8 v1(111.99,8.33)
N19631493: length 1.7
  TOP w0.305: v1(110.09,5.16) 110.09,5.69 R125.2
  BOTTOM w0.305: U12.11 v1(110.09,5.16)
N19631495: length 1.7
  TOP w0.305: R124.2 109.44,5.83 v1(109.44,5.15)
  BOTTOM w0.305: U12.12 v1(109.44,5.15)
N19631505: length 1.5
  TOP w0.305: R126.2 111.53,7.03 v1(112.07,7.03)
  BOTTOM w0.305: U12.10 v1(112.07,7.03)
N19879103: length 22.4
  BOTTOM w0.203: 16.85,12.94 C104.1 16.21,12.93 14.12,12.93 11.89,10.69 9.3,10.69 9.07,10.92 J11.3
  BOTTOM w0.229: 16.85,12.94 25.79,12.94 26.08,13.23 26.08,14.17 25.85,14.4 25.14,14.4 25.01,14.27 U5.15
N19879131:
  vias: v1(7.11,11.68)
N19879145:
  vias: v1(7.11,9.32) v1(8.02,9.32) v1(8.94,9.32) v1(18.67,14.58) v1(18.67,13.92) v1(19.35,14.25) v1(20.04,14.58) v1(20.04,13.92)
N19879149: length 23.7
  BOTTOM w0.203: J11.2 9.06,10.12 9.27,10.34 12.03,10.34 14.27,12.57 16.21,12.57 C103.1
  BOTTOM w0.229: U5.16 25.04,14.92 25.17,14.78 26.01,14.78 26.46,14.33 26.46,13.08 25.95,12.56 16.85,12.56 C103.1
N19879167: length 14.5
  TOP w0.508: v1(25.83,17.45) 28.03,17.45 C101.1
  BOTTOM w0.381: 25.77,17.52 v1(25.83,17.45) ; 21.53,17.52 R95.2
  BOTTOM w0.432: TP4.1 20.6,20.57 ; TP4.1 19.69,20.27 ; TP4.1 21.51,18.44 ; TP4.1 19.38,19.35 ; TP4.1 19.69,18.44 ; TP4.1 20.6,18.14
  BOTTOM w0.508: 21.53,17.52 U5.20 25.77,17.52
N19879302: length 10.4
  TOP w0.127: v1(34.1,16.22) 34.1,21.71 v1(34.78,22.38)
  BOTTOM w0.127: U5.11 v1(34.1,16.22) ; U29.10 v1(34.78,22.38)
N19879304: length 5.4
  TOP w0.127: v1(34.25,23.03) 34.25,22.94 v1(32.72,21.42)
  BOTTOM w0.127: U5.3 v1(32.72,21.42) ; U29.11 v1(34.25,23.03)
N19881704: length 14.5
  L4_SIG w0.127: v1(121.72,29.24) 122.4,29.24 124.97,31.8 126.16,31.8 131.95,37.59 v3(132.72,37.59)
N19881714: length 0.4
  TOP w0.127: v3(126.36,57.91) 126.34,57.91 R89.1
N19881723: length 1.5
  TOP w0.127: R88.1 118.64,29.24 D5.1
N19884870:
  vias: v1(96.95,62.74) v1(96.95,61.87) v1(97.51,62.31) v1(98.07,62.74) v1(98.09,61.87) v1(99.01,62.79) v1(99.97,62.71) v1(101.09,62.69) v1(102.23,62.71)
N19884947:
  vias: v1(104.67,58.67)
N19886018: length 4.1
  BOTTOM w0.203: U3.16 76.16,51.94 76.23,51.87 76.23,51.21 75.9,50.88 75.9,50.16 R64.1
  BOTTOM w0.229: R64.1 75.67,49.8 C9.1
N19886020: length 4.1
  BOTTOM w0.203: U3.15 76.66,51.94 76.59,51.87 76.59,51.06 76.25,50.73 76.25,50.13 R63.1
  BOTTOM w0.229: C8.1 76.43,49.78 R63.1
N19887754: length 2.3
  TOP w0.381: FB8.2 80.21,63.53 v1(80.67,63.53)
  BOTTOM w0.305: v1(80.67,63.53) 80.66,63.52 U3.42
N19887756:
  vias: v2(83.16,62.28) v2(83.16,61.93) v2(83.16,61.57)
N19887760:
  vias: v2(84.15,59.11) v2(84.49,59.11) v2(84.84,59.13)
N19887762:
  vias: v2(84.12,53.59) v2(84.49,53.6) v2(84.86,53.59)
N19887789: length 22.9
  L4_SIG w0.127: v1(55.78,54.08) 57.76,54.08 59.99,56.31 59.99,57.2 61.06,58.27 68.8,58.27 71.15,60.62 74.23,60.62 v1(74.37,60.48)
  BOTTOM w0.127: U3.31 74.5,60.61 v1(74.37,60.48)
N19887795: length 33.6
  L4_SIG w0.127: v1(85.03,61.93) 85.18,61.79 85.18,58.69 84.32,57.82 76.21,57.82 75.79,57.4 70.97,57.4 69.84,56.27 60.79,56.27 v1(58.62,54.1)
  BOTTOM w0.127: U3.48 83.66,62.2 83.79,62.33 84.63,62.33 v1(85.03,61.93)
N19887804: length 24.8
  L4_SIG w0.127: v1(64.36,54.1) 64.85,54.58 70.48,54.58 72.22,56.32 75.76,56.32 76.21,55.87 86,55.87 v1(86.24,56.1)
  BOTTOM w0.127: U3.59 v1(86.24,56.1)
N19887822: length 26.4
  L4_SIG w0.127: v1(85.56,56.6) 85.29,56.87 71.93,56.87 70.1,55.04 62.38,55.04 v1(61.47,54.13)
  BOTTOM w0.127: U3.58 v1(85.56,56.6)
N19887828: length 1.9
  TOP w0.381: C96.1 77.24,52.83 77.93,52.15 v1(78.16,52.15)
  BOTTOM w0.305: U3.12 v1(78.16,52.15)
N19887830: length 1
  TOP w0.254: 78.6,53.07 C97.1 ; 78.6,53.07 78.66,53.01 v2(78.66,52.43) ; 78.6,53.07 v2(78.66,53.14)
  vias: v2(78.66,52.78)
N19887836: length 3.3
  TOP w0.254: 79.17,52.45 79.17,52.76 v2(79.16,52.78) ; 79.17,52.79 v2(79.17,53.14) 79.4,52.91
  TOP w0.305: C88.2 79.29,52.91 v2(79.16,52.78) ; C88.2 v2(79.15,52.43) 79.63,52.73 C88.2
  BOTTOM w0.305: v2(79.16,52.78) v2(79.15,52.43)
  vias: v2(76.15,62.28) v2(76.15,61.57) v2(76.16,61.93) v2(77.65,62.28) v2(77.65,61.57) v2(77.66,61.93)
N19887876: length 1.9
  BOTTOM w0.305: U3.39 79.16,63.31 v1(78.79,63.68)
N19887878: length 1.8
  TOP w0.305: FB9.2 82.16,63.62 v1(82.16,62.78)
  BOTTOM w0.305: U3.45 v1(82.16,62.78)
N19887910: length 1.3
  BOTTOM w0.305: v1(74.35,55.6) v2(75.01,55.6) v2(75.62,55.6)
N19887912: length 1.5
  BOTTOM w0.305: v2(75.49,53.59) 75.06,53.59 v2(75.03,53.62) 74.07,53.62 v1(74.04,53.59)
N19887930: length 1.6
  BOTTOM w0.305: v1(74.35,58.06) 74.39,58.11 U3.26 ; v2(75.54,58.12) v2(74.98,58.12)
N19893167: length 3.1
  TOP w0.483: C372.1 12.74,43.94 v1(12.73,43.93)
N19893194: length 3.1
  TOP w0.483: v1(12.73,41.39) 12.74,41.4 C373.1
N19893222: length 2
  BOTTOM w0.483: C28.2 7.06,43.93 T5.4
N19893438: length 1.6
  BOTTOM w0.483: T5.2 12.21,42.67 v1(10.67,42.67)
N19895463: length 1.3
  TOP w0.229: U32.4 17.65,43.94 C372.2
N19895477: length 1.3
  TOP w0.229: C373.2 17.59,41.4 U33.4
N19955835: length 0.8
  BOTTOM w0.508: U15.4 36.12,6.04 v1(36.12,5.82)
N20015888: length 34.6
  BOTTOM w0.229: C170.2 89.11,58.49 90.56,58.49 94.54,54.51 109.57,54.51 112.75,57.68 115.24,57.68 115.54,57.99 J13.1
N20015984: length 34.8
  BOTTOM w0.229: J14.1 115.54,56.97 115.21,57.3 112.9,57.3 109.73,54.13 94.38,54.13 90.4,58.11 89.07,58.11 C171.2
N20042801: length 1.7
  BOTTOM w0.305: U16.7 56.44,17.86 R139.2
N20043120: length 1.9
  BOTTOM w0.305: U16.6 56.11,18.51 R138.2
N20043460: length 1.7
  BOTTOM w0.305: U16.9 56.47,16.56 R140.2
N20043630: length 1.9
  BOTTOM w0.305: R141.2 56.11,15.91 U16.10
N20048856: length 1.7
  BOTTOM w0.305: R137.2 53.09,21.33 U16.4
N20080651: length 11.6
  TOP w0.508: v1(41.84,24.98) 41.57,24.98 40.34,26.21 SJP5.2
  BOTTOM w0.305: v1(41.84,24.98) 38.75,24.98 37.59,23.83 37.59,21.49 37.18,21.08 U29.8
N20101312: length 2.6
  TOP w0.305: U14.3 46.01,3.32 R132.2 R134.1
N20101314: length 16.6
  TOP w0.381: 45.71,11.98 45.85,10.31 45.76,9.37 ; 45.71,11.98 45.34,11.1 45.34,10.03 45.76,9.37 ; 45.71,11.98 45.53,11.8 45.53,9.86 45.76,9.37 ; 45.71,11.98 46.1,11.13 46.1,9.93 45.76,9.37 ; 45.76,9.37 45.76,12 L1.1 ; 45.76,9.37 U14.6
N20101373: length 3.5
  L4_SIG w0.305: v1(48.07,4.32) 47.69,4.7 v2(45.51,4.7) ; v2(45.52,5.08) v2(45.52,4.34)
N20111831: length 2.6
  TOP w0.305: U11.3 R154.2 R155.1
N20111833: length 13.4
  TOP w0.381: L2.1 59.87,11.64 59.87,10.79 59.69,10.39 ; L2.1 59.16,11.75 59.16,11.04 59.43,10.36 ; L2.1 59.69,10.39 ; L2.1 59.43,12.64 59.43,10.36 ; 59.43,10.36 59.43,9.78 ; 59.43,9.78 59.69,10.39 ; 59.43,9.78 U11.6
N20111884: length 4.3
  TOP w0.305: U11.2 v1(59.18,4.8)
  L6_PWR w0.305: v1(59.18,4.8) 60.02,5.64 61.24,5.64 v1(62.03,4.85)
N20113515: length 4.2
  BOTTOM w0.381: R143.2 75.74,14.25 75.59,14.41 U17.16 ; R143.2 77.55,14.25 C193.2 ; R143.2 R145.1
N20114896: length 2.9
  TOP w0.305: v1(84.23,5.92) 84.08,6.06 U18.4
  TOP w0.508: v1(84.23,5.92) 84.23,5.79 v1(84.61,5.41) v1(85.75,5.41)
  vias: v1(85.5,15.57) v1(85.5,14.81) v1(85.45,14.05) v1(85.5,13.28) v1(85.5,12.52) v1(86.21,14.05) v1(86.26,15.57) v1(86.26,14.81) v1(86.26,13.28) v1(86.26,12.52) v1(87.15,15.57) v1(87.15,14.81) v1(87.1,14.05) v1(87.15,13.28) v1(87.15,12.52)
N20114915: length 2.7
  TOP w0.305: R147.1 R146.2 83.58,5.42 U18.3
N20114917: length 20.8
  TOP w0.305: 83.33,11.07 83.42,11.32 ; 83.33,11.07 83.13,11.6 ; 83.33,11.07 83.33,13.97 L3.1 ; 83.33,11.07 U18.6 ; 83.42,11.32 L3.1 ; 83.42,11.32 83.67,12.06 ; 83.13,11.6 L3.1 ; 83.13,11.6 82.93,12.12 ; L3.1 83.69,12.78 83.67,12.06 ; L3.1 83.67,12.06 ; L3.1 82.83,12.85 82.8,12.6 82.93,12.12 ; L3.1 82.93,12.12
N20150497: length 5.8
  TOP w0.508: v1(51.79,14.81) 51.79,14.9 50.94,15.75 47.6,15.75 v1(46.79,14.94)
N20151052:
  vias: v1(70.63,15.71)
N20152729: length 2.1
  TOP w0.305: U18.1 82.58,6.56 81.81,5.79 SJP4.2
N20213760:
  vias: v1(114.45,6.73)
N20220794:
  vias: v1(94.61,18.16) v1(94.61,17.14) v1(94.61,16.13) v1(95.5,18.16) v1(95.5,17.14) v1(95.5,16.13) v1(96.39,18.16) v1(96.39,17.14) v1(96.39,16.13)
N20220969: length 1.4
  TOP w0.305: v1(95.46,6.44) 95.46,7.18 C387.1
  BOTTOM w0.305: U31.14 v1(95.46,6.44)
N20220990: length 1.5
  TOP w0.305: v1(99.24,9.53) 98.48,9.53 R171.2
  BOTTOM w0.305: U31.8 v1(99.24,9.53)
N20220992: length 1.4
  TOP w0.305: v1(97.71,6.5) R172.2
  BOTTOM w0.305: v1(97.71,6.5) 97.41,6.8 U31.11
N20220994: length 1.7
  TOP w0.305: v1(96.76,6.36) 96.76,7.02 R170.2
  BOTTOM w0.305: U31.12 v1(96.76,6.36)
N20221006: length 1.2
  TOP w0.305: v1(98.78,7.72) R173.2
  BOTTOM w0.305: U31.10 98.68,8.23 98.78,8.13 v1(98.78,7.72)
N20227487: length 2.6
  BOTTOM w0.305: U30.27 39.39,62.19 39.3,62.28 38.76,62.28 C400.2 38.13,62.2 v1(38.13,62.18)
N20231187: length 2.4
  BOTTOM w0.305: U30.3 48.58,62.69 C403.2
N20232417: length 1
  BOTTOM w0.305: U30.38 44.66,65.49 v1(44.68,65.51)
N20232915: length 1.4
  BOTTOM w0.305: v1(39.04,63.27) 39.12,63.19 U30.29
N20233092: length 2.9
  TOP w0.305: v1(43.74,65.61) 43.56,65.79 C406.2 v2(43.56,65.99)
  BOTTOM w0.305: 43.66,65.6 43.66,65.89 ; 43.66,65.6 U30.36 ; 43.66,65.6 43.66,65.61 v1(43.74,65.61) ; 43.66,65.89 v2(43.56,65.99) 43.56,65.79 v1(43.74,65.61) ; 43.66,65.89 43.74,65.81 v1(43.74,65.61)
N20234062: length 0.9
  TOP w0.305: v2(42.16,64.85) 41.96,64.64 C407.2 42.16,64.34 v2(42.16,64.11)
  vias: v2(42.16,64.47)
N20235277: length 7.2
  BOTTOM w0.229: U30.23 39.71,60.19 R175.1 37.04,60.08 34.56,60.08 C409.1
N20235286: length 7.2
  BOTTOM w0.229: U30.22 39.7,59.69 R176.1 37.15,59.7 34.48,59.7 C410.1
N20237052: length 3.9
  BOTTOM w0.229: C412.1 R177.1 43.22,56.36 42.15,57.43 42.15,58.41 U30.18
N20237066: length 3.9
  BOTTOM w0.229: U30.19 41.66,57.51 R178.1 C413.1
N20239082: length 2.2
  BOTTOM w0.127: U30.30 39.63,63.69 39.12,64.21 R179.2
N20249678: length 1.1
  TOP w0.305: 46.25,59.18 46.2,59.23 46.41,59.23 v2(46.46,59.18) ; 46.25,59.18 v2(46.46,59.18) ; 46.25,59.18 v2(46.08,59.18) ; v2(46.46,59.18) v2(46.79,59.18)
N20251064: length 1.5
  BOTTOM w0.229: 51.44,66.32 51.44,67.08 ; C394.2 R174.1
N20251377: length 1.7
  BOTTOM w0.229: C420.1 R183.1 R182.2
N20251505: length 5.8
  BOTTOM w0.229: R183.2 46.2,66.32 C421.1 46.08,66.45 43.33,66.45 43.1,66.22 43.1,65.33 43.16,65.27 U30.35
N20257347: length 14.8
  L4_SIG w0.127: v1(40.56,66.5) 41.58,65.48 41.58,63.65 41.27,63.35 41.27,58.47 39.17,56.36 v1(39.09,56.36)
  BOTTOM w0.127: U30.20 41.16,58.08 39.45,56.36 v1(39.09,56.36)
N20258125:
  vias: v1(39.85,66.5)
N20306930: length 1.4
  TOP w0.229: U32.6 18.67,43.98 18.9,43.75 18.9,43.28 C429.1
N20306944: length 1.5
  TOP w0.229: U33.6 18.69,41.31 18.92,41.54 18.92,42.09 C430.1
N198851401: length 0.9
  BOTTOM w0.305: C71.2 R54.1
N198852420: length 1
  BOTTOM w0.305: R47.1 72.24,60.22 C70.2

## Copper pours and planes (outline as drawn)
1.4V on TOP: 61.77,8.66 61.77,10.67 61.37,11.07 61.37,14.5 63.55,14.5 64.31,13.74 64.31,9.17 63.8,8.66
1.4V on BOTTOM: 61.39,9.98 61.39,14.83 67.59,14.83 67.59,16.33 69.9,16.33 69.9,11.07 70.79,11.07 70.79,9.86 69.57,8.64 62.74,8.64
5.0V_IN on TOP (solid shape): 36.5,7.23 31.98,7.23 31.98,11.04 36.5,11.04
5.0V_IN on TOP, BOTTOM, L4_SIG, L6_PWR: 19.68,7.62 19.68,10.79 20.55,11.66 36.47,11.66 37.26,10.87 37.26,8.05 36.2,6.99 20.32,6.99
5VIN on TOP: 58.98,10.19 58.98,5.05 57.35,5.05 57.35,10.19
5VIN on TOP: 39.8,9.07 39.8,7.19 42.98,7.19 42.98,9.07
5VIN on TOP: 82.83,11.63 82.83,7.82 80.92,7.82 80.54,8.2 80.54,11.25 80.92,11.63
5VIN on TOP: 45.21,9.4 45.21,4.27 43.59,4.27 43.59,9.4
5VIN on TOP, BOTTOM: 31.8,6.17 31.8,3.25 35.23,3.25 35.23,6.17
5VIN on BOTTOM: 58.65,9.8 58.65,5.11 57.33,5.11 57.33,9.8
5VIN on BOTTOM: 44.96,9.02 44.96,4.32 43.56,4.32 43.56,9.02
5VIN on BOTTOM: 90.86,6.93 90.86,8.53 94.18,8.53 94.18,7.67 96.32,7.67 96.32,5.66 95.83,5.18 92.61,5.18
5VIN on BOTTOM: 20.42,16.54 20.42,15.04 22.63,15.04 22.63,16.54
5VIN on BOTTOM: 82.58,11.25 82.58,8.08 80.54,8.08 80.54,11.25
5VIN on BOTTOM: 103.53,5.61 103.53,6.35 104.04,6.35 104.9,7.21 106.86,7.21 106.86,6.35 108.99,6.35 108.99,4.34 108.51,3.86 105.28,3.86
5VIN on BOTTOM: 40.06,7.44 40.06,9.09 42.47,9.09 42.47,7.44
5VIN on L3_PWR: 20.07,8.61 20.07,16.51 106.68,16.51 106.68,1.91 26.77,1.91
+2.2V on TOP: 47.5,8.26 47.5,13.79 49.02,15.32 50.8,15.32 52.58,13.54 52.58,8.26
+2.2V on BOTTOM: 47.5,15.19 47.5,9.4 48.51,8.38 52.58,8.38 52.58,15.37 50.67,15.37 50.67,16.69 49,16.69
+3.3V_LMX on TOP: 43.03,63.6 43.03,65.23 44.88,65.23 44.88,63.6
+3.3V_LMX on TOP: 102.11,19.43 102.11,27.05 97.54,27.05 97.41,26.92 97.41,22.35 100.33,19.43
+3.3V_LMX on L3_PWR: 97.46,21.59 97.46,31.11 69.85,31.11 42.55,58.42 40.51,58.42 39.62,59.31 39.62,66.04 50.8,66.04 75.56,41.27 106.05,41.27 106.05,21.59
+3.3V_LMXRF on TOP: 94.23,19.56 94.23,25.65 96.65,25.65 96.65,19.56
+3.3V_LMXRF on BOTTOM: 23.75,61.11 23.75,62.51 25.65,62.51 25.65,61.11
+3.3V_LMXRF on L3_PWR: 96.62,19.05 96.62,29.84 69.22,29.84 41.91,57.15 40.11,57.15 38.68,58.57 38.68,66.04 23.67,66.04 23.67,58.88 63.5,19.05
+3.3VCLK on TOP: 73.15,58.93 73.15,55.12 72.9,54.86 72.9,53.24 72.85,53.19 71.55,53.19 71.55,54.36 71.91,54.71 71.91,58.93
+3.3VCLK on TOP: 77.95,64.52 76.28,64.52 76.28,66.14 77.09,66.95 77.95,66.95
+3.3VCLK on TOP: 86.92,53.21 86.92,51.56 88.06,51.56 88.06,53.21
+3.3VCLK on TOP: 111.3,24.84 111.3,18.31 115.8,18.31 115.8,24.84
+3.3VCLK on TOP: 85.62,59.75 85.62,61.19 85.85,61.42 86.92,61.42 86.92,59.75
+3.3VCLK on BOTTOM: 110.87,17.91 110.87,19.3 111.12,19.56 111.12,24.51 114.05,24.51 115.54,23.01 115.54,20.29 113.16,17.91
+3.3VCLK on L6_PWR: 107.31,19.96 107.31,46.1 103.25,50.16 62.66,50.16 62.66,66.67 109.86,66.67 121.28,55.24 121.28,16.51 110.77,16.51
AVDD1.9V on TOP: 47.47,24.71 47.47,21.49 52.88,21.49 52.88,24.94 49.78,24.94 49.56,24.71
AVDD1.9V on BOTTOM: 47.24,19.68 47.24,20.83 47.52,21.11 47.52,24.66 49.05,24.66 49.4,25.02 52.07,25.02 52.45,24.64 52.45,21.08 51.94,20.57 51.94,19.05 50.55,19.05 50.55,17.65 49.28,17.65
AVDD1.9V on L3_PWR: 9.53,26.04 9.53,41.27 15.37,47.12 20.95,47.12 20.95,51.44 28.57,51.44 28.57,33.66 20.85,33.66 20.85,35.56 19.68,35.56 19.05,34.92 19.05,30.48 23.47,26.06 52.93,26.06 52.93,17.14 18.41,17.14
AVDD1.15V on BOTTOM: 74.86,21.24 68.17,21.24 68.17,24.92 71.22,24.92 71.22,24.03 71.68,23.57 78.03,23.57 78.03,21.23 74.85,21.23
AVDD1.15V on L6_PWR: 9.53,25.2 9.53,41.27 15.24,46.99 20.95,46.99 20.95,51.44 28.32,51.44 28.32,39.12 28.07,38.86 28.07,33.66 20.95,33.66 20.95,37.41 19.63,37.41 19.05,36.83 19.05,30.48 24.18,25.35 72.92,25.35 72.92,15.75 18.97,15.75
DVDD1.15V on TOP: 39.55,27.58 39.55,26.29 38.25,26.29 38.25,27.86 39.27,27.86
DVDD1.15V on TOP: 88.57,18.26 88.57,21.01 85.88,23.7 83.97,23.7 82.7,22.43 82.7,19.28 83.72,18.26
DVDD1.15V on BOTTOM: 83.19,17.93 83.19,23.27 86.44,23.27 86.44,17.93
DVDD1.15V on L6_PWR: 66.55,34.92 44.45,34.92 44.45,26.42 32.64,26.42 28.96,30.1 28.96,35.43 28.45,35.94 28.45,37.85 28.96,38.35 28.96,47.47 28.7,47.75 28.7,51.44 44.45,51.44 44.45,46.35 72.42,46.35 88.9,29.87 88.9,18.16 77.47,18.16 77.47,24
GND on TOP: 0.25,68.33 0.25,0.25 139.45,0.25 139.45,68.33 ; 1 cut-out
GND on BOTTOM: 0.25,68.33 0.25,0.25 139.45,0.25 139.45,68.33 ; 2 cut-outs
GND on L2_GND, L3_PWR, L5_GND, L6_PWR, L7_GND: 0.25,68.33 0.25,0.25 139.45,0.25 139.45,68.33
GND on L4_SIG: 0.25,68.33 0.25,0.25 139.45,0.25 139.45,68.33 ; 2 cut-outs
AINM on TOP (solid shape): 25.51,38 25.5,37.66 25.58,36.42 25.58,36.2 24.94,36.2 24.94,36.41 24.98,36.6 25.26,37.67 25.26,38.01
AINP on TOP (solid shape): 26.01,37.68 26.45,36.57 26.45,36.19 25.82,36.19 25.82,36.55 25.76,37.67 25.76,38 26,38
BINM on TOP (solid shape): 25.76,49.15 25.5,47.85 25.5,47.48 25.27,47.48 25.27,47.9 25.14,49.09 25.13,49.63 25.77,49.63
BINP on TOP (solid shape): 26.65,49.47 26.65,48.99 26.64,48.93 26.43,48.56 26.01,47.86 26,47.47 25.77,47.47 25.77,47.84 25.89,48.47 26.02,49.05 26.02,49.47
U17_BYPASS on BOTTOM: 60.88,15.39 60.88,17.81 62.66,19.58 73.2,19.58 73.2,17.42 63.93,17.42 63.3,16.79 63.3,15.39
N19631315 on BOTTOM: 105.03,9.53 105.03,12.19 106.68,12.19 106.93,12.45 106.93,16.89 111.25,16.89 111.63,16.51 112.65,16.51 112.65,13.97 109.73,13.97 109.22,13.46 109.22,10.16 106.93,10.16 106.93,9.53
N19879145 on TOP: 6.83,8.26 6.83,10.79 11.43,10.79 16.51,15.88 19.08,15.88 20.27,14.68 20.27,13.82 19.79,13.34 17.78,13.34 12.7,8.26
N19879167 on BOTTOM: 22.02,17.14 22.02,19.84 21.06,20.8 19.46,20.8 18.39,19.74 18.39,17.14
N19887756 on TOP: 78.36,64.87 78.36,66.83 82.88,66.83 82.88,66.62 84.2,65.28 84.2,61.52 84.1,61.42 83.11,61.42 83.01,61.52 83.01,64.49 82.68,64.82 78.41,64.82
N19887760 on TOP: 84.02,60.77 84.02,58.81 84.98,58.81 84.98,60.77
N19887762 on TOP: 83.97,52.1 83.97,54.05 85.04,54.05 85.04,52.1
N19887836 on TOP: 75.9,61.42 75.9,62.33 76.89,63.32 76.89,64.06 77.93,64.06 77.93,63.02 78.13,62.81 78.13,61.42
